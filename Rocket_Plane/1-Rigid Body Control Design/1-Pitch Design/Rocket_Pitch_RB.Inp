BATCH MODE INSTRUCTIONS ...............                                                             
Batch Set for Creating Rigid-Body Models for the Rocket-Plane 
! This batch set is used to create pitch systems for control design and simulations 
! of the rocket-plane vehicle. It creates also a mixing-logic matrix and converts them to 
! Matlab format to be used in Simulink 
!                                                                                                                                                                                     
Retain Matrix    : State Penalty Matrix Qc4          
Retain Matrix    : Control Penalty Rc                        
Flight Vehicle   : Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                                                                             
Mixing Matrix    : Pitch axis Mixing Matrix for Rocket-Plane, Kmix_qa                                                                                                                                          
Transf-Functions : First Order Gust Lag                                                                                                                                                                                     
Transf-Functions : Integrator                                                                                                                                                                                               
System Modificat : Rocket Plane at Mach=0.85, Q=150, Rigid Body, Pitch Axis                                                                                                                                                 
System Modificat : Pitch Design Model                                                                                                                                                                                       
System Connection: Pitch Design Model with Alpha Integral (2-inputs, 4-states)                                                                                                                                                          
System Modificat : Pitch Design Model with Alpha Integral (1-input, 4-states)   
LQR Control Des  : Pitch LQR Control Design                                                                                                                                                        
!
To Matlab Format : Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                                                                             
To Matlab Format : Rocket Plane at Mach=0.85, Q=150, Rigid Body, Pitch Axis                                                                                                                                                 
To Matlab Format : Pitch Design Model with Alpha Integral (1-input, 4-states)                                                                                                                                                        
To Matlab Format : Pitch axis Mixing Matrix for Rocket-Plane, Kmix_qa                                                                                                                                          
To Matlab Format : LQR State-Feedback Control for Pitch Axis                                                                                                           
----------------------------------------------------------------------------------------------------------------------------------------------------------------------                                                                                   
FLIGHT VEHICLE INPUT DATA ......                                                                    
Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                          
! The following vehicle model is a rigid body rocket plane. It has five control surfaces,                                                                                                                                   
! 2 flaps, 2 rudders, and a body-flap. It also has a fixed engine with variable thrust for                                                                                                                                  
! speed control. In this model the tail-wags-dog option is turned off.                                                                                                                                                      
! It will be used to create state-space models for control design.                                                                                                                                                          
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination                                                                                                                                                   
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  198.32       32.17        0.20896E+08                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  1098.0       10933.       11290.       0.0000       123.75       0.0000                                                         
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -15.167       0.0000       0.467                                                                                                 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.85000      822.80       150.00       45880.                                                                                   
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -0.81        -1.14         0.0000      -32.15                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.0          0.0          1.76         0.0000                                                                                   
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.16079      2.0000       0.0000       0.0000       0.0000       0.0000                                                         
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0                                                                                                  
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  79.069       6.1170       14.910                                                                                                
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -14.792       0.0000      0.54000       0.0000                                                                                   
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.143,  -0.0039,   0.0004, 0.0,    0.0,    -0.244,  0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.0245,   1.77,   0.0,    0.00838, 0.0,    0.0                                                                         
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.14,   -0.073,   -9.93,   0.0,    0.0,     0.0,    0.00093                                                                     
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.00212,  0.0,   -0.393,  0.427,   0.0                                                                                 
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.0838, -0.015,    0.0,    0.0,   -12.83,   0.0004, 0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,     0.001,    0.0,    0.184, -1.49,    0.0                                                                                 
                                                                                                                                                                                                                            
Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  5   NO TWD                                                                                                                      
                                                                                                                                                                                                                            
Control Surface No:  1                                                                     Left Flap                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0           30.000     -30.000       +2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.2867       0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7       -2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03 -0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.11893E-02 -0.26625E-02  0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  2                                                                     Right Flap                                                                                                                       
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0           30.000     -30.000       -2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.2867       0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7        2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03  0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.11893E-02 -0.26625E-02 -0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  3                                                                     Left Rudder                                                                                                                      
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000        48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        3.914        0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019        0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333    -3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03  0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.17964E-02 -0.98720E-02 -0.35668E-02   0.0000       0.0000       0.0000                                                        
Control Surface No:  4                                                                     Right Rudder                                                                                                                     
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000       -48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        3.914        0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019       -0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333     3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03 -0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.17964E-02 -0.98720E-02  0.35668E-02   0.0000       0.0000       0.0000                                                        
Control Surface No:  5                                                                     Body Flap                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -10.0         40.000      -40.000       0.0000       0.0000                                                                     
Surface Mass, Inertia about Hinge, Moment Arm (hinge to surface CG), Surface Chord & Area:   1.8          2.2         0.6           1.6670       5.7430                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.1e-03       0.0000     -0.10E-03      0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.8         0.0000      0.80000                                                                                               
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.83830E-05   0.0000     -0.59235E-03   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.0000     -0.15765E-02   0.0000       0.0000       0.0000       0.0000                                                        
                                                                                                                                                                                                                            
Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  1   NO TWD                                                                                                                      
                                                                                                                                                                                                                            
TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Engine Throtl    Throttling                                                                                                      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  2000.0        4000.0                                                                                                            
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  -1.3          0.0         0.0           0.0                                                                                     
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   2.00         65.0        0.8                                                                                                   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -26.5         0.0         0.0                                                                                                   
------------------------------------------------------------------------------------------------------------------------------------------------------------------                                                                                   
MIXING LOGIC MATRIX DATA .........    (MATRIX TITLE, NAME, VEHICLE TITLE, CONTROL DIRECTIONS)       
Pitch axis Mixing Matrix for Rocket-Plane, Kmix_qa                                                                                       
! Mixing Logic Matrix for the rocket-plane in the pitch axis. It converts the pitch and                                                                                                                                     
! axial acceleration demands to five aero-surface deflections and engine thrust variation                                                                                                                                   
Kmix_qa                                                                                                                                                                                                  
Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                                                                                                
Q-dot Pitch Acceleration About Y Axis                                                                                                                                                                                       
Ax  Forward Acceleration Along X Axis                                                                                                                                                                                       
------------------------------------------------------------------------------------------------------------------------                                                                                                    
SYSTEM OF TRANSFER FUNCTIONS ...                                                                    
First Order Gust Lag                                                                                                                                  
! A low-pass filter 0.5 (rad/sec) to smooth out the input gust                                                                                                                                                              
Continuous                                                                                                                                                                                                                  
TF. Block #  1 First Order Lag                                   Order of Numer, Denom=  0  1                                                                                                                               
Numer 0.0         0.5                                                                                                                                                                                                       
Denom 1.0         0.5                                                                                                                                                                                                       
-------------------------------------------------------------------------------                                                                                                                                             
Block #, from Input #, Gain                                                                                                                                                                                                 
  1  1    1.0                                                                                                                                                                                                               
...........................                                                                                                                                                                                                 
Outpt #, from Block #, Gain                                                                                                                                                                                                 
  1  1    1.0                                                                                                                                                                                                               
...........................                                                                                                                                                                                                 
----------------------------------------------------------------------------------------------------------------------------                                                                                                
SYSTEM OF TRANSFER FUNCTIONS ...                                                                    
Integrator                                                                                                                                            
Continuous                                                                                                                                                                                                                  
TF. Block #  1 First Order Lag                                   Order of Numer, Denom=  0  1                                                                                                                               
Numer 0.0         1.0                                                                                                                                                                                                       
Denom 1.0         0.0                                                                                                                                                                                                       
-------------------------------------------------------------------------------                                                                                                                                             
Block #, from Input #, Gain                                                                                                                                                                                                 
  1  1    1.0                                                                                                                                                                                                               
...........................                                                                                                                                                                                                 
Outpt #, from Block #, Gain                                                                                                                                                                                                 
  1  1    1.0                                                                                                                                                                                                               
...........................                                                                                                                                                                                                 
--------------------------------------------------------------------------------------------------------------------------------------                                                                                      
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (TITLES OF THE NEW AND OLD SYSTEMS)                       
Rocket Plane at Mach=0.85, Q=150, Rigid Body, Pitch Axis                                                                                              
Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                                                                                                
! The rigid pitch axis model is extracted from the previously created coupled                                                                                                                                               
! rigid-body model                                                                                                                                                                                                          
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS                                                                                                                                                                  
Extract States :   3   4   7   9  10                                                                                                                                                                                        
Extract Outputs:   3   4   7   9  10  12  14                                                                                                                                                                                
--------------------------------------------------------------------------------------------------------------------------------------                                                                                      
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (TITLES OF THE NEW AND OLD SYSTEMS)                       
Pitch Design Model                                                                                                                                    
Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                                                                                                
! The pitch axis control design system is extracted from the coupled system                                                                                                                                             
! The wind-gust input is not used. 
! The states and outputs are: theta, q, and alpha                                                                                             
!                                                                                                                                                                                                      
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS                                                                                                                                                                  
Extract Inputs :   1   2   3   4   5   6                                                                                                                                                                                    
Extract States :   3   4   7                                                                                                                                                                                                
Extract Outputs:   3   4   7                                                                                                                                                                                                
--------------------------------------------------------------------------------------------------------------------------------------                                                                                      
INTERCONNECTION OF SYSTEMS .....                                                                    
Pitch Design Model with Alpha Integral (2-inputs, 4-states)                                                                                                     
! The pitch axis control design model is augmented with the integral of the angle                                                                                                                                           
! of attack for control design. 
! The states and outputs are: theta, q, alpha, and alpha-integral                                                                                        
! The mixing matrix Kmix_qa is included in the input which reduces the inputs to two
! Pitch and Axial Acceleration Demands
!                                                                                                                                                            
Titles of Systems to be Combined       (from File RocketPlane_RB.QDR)                                                                                                                                                       
Title 1 Pitch Design Model                                                                                                                                                                                                  
Title 2 Integrator                                                                                                                                                                                                          
SYSTEM INPUTS TO SUBSYSTEM  1                                                                                                                                                                                               
Via Matrix +Kmix_qa                                                             Pitch, Axial Demands                                                                                                                                            
..............................................................................                                                                                                                                              
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                All Outputs                                                                                                                                 
Via Matrix +I3                                                                                                                                                                                                              
..............................................................................                                                                                                                                              
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                                                                                                                                            
System Output  4 from Subsystem  2, Output  1, Gain= 1.0                        Alpha Integral                                                                                                                              
..............................................................................                                                                                                                                              
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                         Vehicle alpha to Integrator                                                                                                                 
Subsystem  1, Output  3 to Subsystem  2, Input  1, Gain= 1.0                    Alpha Integral                                                                                                                              
..............................................................................                                                                                                                                              
Definitions of Inputs  =   2                                                                                                                                                                                                
Pitch Acceleration
Axial Acceleration
                                                                                                                                                                                                                            
Definitions of States  =   4                                                                                                                                                                                                
Pitch Attitude    (theta-rigid)  (radians)                                                                                                                                                                                  
Pitch Rate        ( q -rigid)    (rad/sec)                                                                                                                                                                                  
Angle of attack   (alpha)        (radians)                                                                                                                                                                                  
Alpha Integral                   (rad-sec)                                                                                                                                                                                  
                                                                                                                                                                                                                            
Definitions of Outputs =   4                                                                                                                                                                                                
Pitch Attitude    (theta-rigid)  (radians)                                                                                                                                                                                  
Pitch Rate        ( q -rigid)    (rad/sec)                                                                                                                                                                                  
Angle of attack   (alpha)        (radians)                                                                                                                                                                                  
Alpha Integral                   (rad-sec)                                                                                                                                                                                  
--------------------------------------------------------------------------------------------------------------------------------------                                                                                      
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (TITLES OF THE NEW AND OLD SYSTEMS)                       
Pitch Design Model with Alpha Integral (1-input, 4-states)                                                                                            
Pitch Design Model with Alpha Integral (2-inputs, 4-states)                                                                                                                                                             
! Eliminate the second input (Ax acceleration) from the pitch design model                                                                                                                                
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS                                                                                                                                                                  
Extract Inputs :   1                                                                                                               
--------------------------------------------------------------------------------------------------------------------------------                                                                                            
LINEAR QUADRATIC REGULATOR STATE-FEEDBACK CONTROL DESIGN                                                                                                                                                
Pitch LQR Control Design                                                                                                                                                        
Plant Model Used to Design the Control System from:        Pitch Design Model with Alpha Integral (1-input, 4-states)                                                                                                                    
Criteria Optimization Output is Matrix C                                                                                                                                                                
State Penalty Weight (Qc) is Matrix:   Qc4                 State Penalty Matrix Qc4                                                                                                                
Control Penalty Weight (Rc) is Matrix: Rc                  Control Penalty Rc                                                                                                                     
Continuous LQR Solution Using Laub Method                                                                                                                                                               
LQR State-Feedback Control Gain Matrix Kq                  LQR State-Feedback Control for Pitch Axis                                                                                      
--------------------------------------------------------------------------------------------------------------------------------                                                                                            
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                          
System                                                                                                                                                                                                                      
Vehi_Coupled_rb.m                                                                                                                                                                                                           
------------------------------------------------------------------------------------------------------------------------                                                                                                    
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Rocket Plane at Mach=0.85, Q=150, Rigid Body, Pitch Axis                                                                                              
System                                                                                                                                                                                                                      
Vehi_Pitch_rb.m                                                                                                                                                                                                             
------------------------------------------------------------------------------------------------------------------------                                                                                                    
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Pitch Design Model with Alpha Integral (1-input, 4-states)                                                                                                     
System                                                                                                                                                                                                                      
Vehi_PDes_4x.m                                                                                                                                                                                                              
------------------------------------------------------------------------------------------------------------------------                                                                                                    
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Pitch axis Mixing Matrix for Rocket-Plane, Kmix_qa                                                                                      
Matrix Kmix_qa                                                                                                                                                                                                              
------------------------------------------------------------------------------------------------------------------------                                                                                                    
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
LQR State-Feedback Control for Pitch Axis                                                                                   
Matrix Kq                                                                                                                                                                                                              
------------------------------------------------------------------------------------------------------------------------                                                                                                    
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
