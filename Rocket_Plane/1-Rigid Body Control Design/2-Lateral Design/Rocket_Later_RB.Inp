BATCH MODE INSTRUCTIONS ...............                                                             
Batch Set for Creating Rigid-Body Models for the Rocket-Plane 
! This batch set is used to create pitch and lateral models for control design and simulations 
! of the rocket-plane vehicle. It creates also a mixing-logic matrix and converts them to 
! Matlab format to be used in Simulink 
!                                                                                                                                                                                     
Retain Matrix    : State Penalty Matrix Qc4          
Retain Matrix    : Control Penalty Matrix Rc2                             
Flight Vehicle   : Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                                                                             
Flight Vehicle   : Rocket Plane at Mach=0.85, Q=150, Rigid Body (for computing the lateral mixing matrix Kmix)                                                                                                              
Transf-Functions : First Order Gust Lag                                                                                                                                                                                     
Transf-Functions : Integrator                                                                                                                                                                                               
System Modificat : Rocket Plane at Mach=0.85, Q=150, Rigid Body, Lateral Axes                                                                                                                                               
Mixing Matrix    : Lateral axes Mixing Matrix for Rocket-Plane, Kmix                                                                                                                                              
System Modificat : Lateral Design Model                                                                                                                                                                                     
System Connection: Lateral Design Model with p-Integral (4-states)                                                                                                                                                          
LQR Control Des  : Lateral LQR Control Design                                                                                                                                                        
!
To Matlab Format : Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                                                                             
To Matlab Format : Rocket Plane at Mach=0.85, Q=150, Rigid Body, Lateral Axes                                                                                                                                               
To Matlab Format : Lateral Design Model with p-Integral (4-states)                                                                                                                                                          
To Matlab Format : Lateral axes Mixing Matrix for Rocket-Plane, Kmix                                                                               
To Matlab Format : LQR State-Feedback Control for Lateral Axis                                                                                 
----------------------------------------------------------------------------------------------------------------------------------------------------------------------                                                                                   
FLIGHT VEHICLE INPUT DATA ......                                                                    
Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                          
! The following vehicle model is a rigid body rocket plane. It has five control surfaces,                                                                                                                                   
! 2 flaps, 2 rudders, and a body-flap. It also has a fixed engine with variable thrust for                                                                                                                                  
! speed control. In this model the tail-wags-dog option is turned off.                                                                                                                                                      
! It will be used to create state-space models for control design.                                                                                                                                                          
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination                                                                                                                                                   
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  198.32       32.17        0.20896E+08                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  1098.0       10933.       11290.       0.0000       123.75       0.0000                                                         
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -15.167       0.0000       0.467                                                                                                 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.85000      822.80       150.00       45880.                                                                                   
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -0.81        -1.14         0.0000      -32.15                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.0          0.0          1.76         0.0000                                                                                   
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.16079      2.0000       0.0000       0.0000       0.0000       0.0000                                                         
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0                                                                                                  
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  79.069       6.1170       14.910                                                                                                
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -14.792       0.0000      0.54000       0.0000                                                                                   
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.143,  -0.0039,   0.0004, 0.0,    0.0,    -0.244,  0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.0245,   1.77,   0.0,    0.00838, 0.0,    0.0                                                                         
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.14,   -0.073,   -9.93,   0.0,    0.0,     0.0,    0.00093                                                                     
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.00212,  0.0,   -0.393,  0.427,   0.0                                                                                 
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.0838, -0.015,    0.0,    0.0,   -12.83,   0.0004, 0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,     0.001,    0.0,    0.184, -1.49,    0.0                                                                                 
                                                                                                                                                                                                                            
Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  5   NO TWD                                                                                                                      
                                                                                                                                                                                                                            
Control Surface No:  1                                                                     Left Flap                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0           30.000     -30.000       +2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.2867       0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7       -2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03 -0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.11893E-02 -0.26625E-02  0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  2                                                                     Right Flap                                                                                                                       
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0           30.000     -30.000       -2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.2867       0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7        2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03  0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.11893E-02 -0.26625E-02 -0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  3                                                                     Left Rudder                                                                                                                      
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000        48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        3.914        0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019        0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333    -3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03  0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.17964E-02 -0.98720E-02 -0.35668E-02   0.0000       0.0000       0.0000                                                        
Control Surface No:  4                                                                     Right Rudder                                                                                                                     
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000       -48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        3.914        0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019       -0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333     3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03 -0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.17964E-02 -0.98720E-02  0.35668E-02   0.0000       0.0000       0.0000                                                        
Control Surface No:  5                                                                     Body Flap                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -10.0         40.000      -40.000       0.0000       0.0000                                                                     
Surface Mass, Inertia about Hinge, Moment Arm (hinge to surface CG), Surface Chord & Area:   1.8          2.2         0.6           1.6670       5.7430                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.1e-03       0.0000     -0.10E-03      0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.8         0.0000      0.80000                                                                                               
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.83830E-05   0.0000     -0.59235E-03   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.0000     -0.15765E-02   0.0000       0.0000       0.0000       0.0000                                                        
                                                                                                                                                                                                                            
Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  1   NO TWD                                                                                                                      
                                                                                                                                                                                                                            
TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Engine Throtl    Throttling                                                                                                      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  2000.0        4000.0                                                                                                            
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  -1.3          0.0         0.0           0.0                                                                                     
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   2.00         65.0        0.8                                                                                                   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -26.5         0.0         0.0                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                           
------------------------------------------------------------------------------------------------------------------------------------------------------------------                                                                                   
FLIGHT VEHICLE INPUT DATA ......                                                                    
Rocket Plane at Mach=0.85, Q=150, Rigid Body (for computing the lateral mixing matrix Kmix)                                                           
! The following vehicle model is a rigid body rocket plane. It has four control surfaces,                                                                                                                                   
! 2 flaps, and 2 rudders. It is used to calculate the lateral mixing matrix Kmix                                                                                                                                           
Body Axes Output, Attitude=Euler Angles, Without GAFD, No Turn Coordination                                                                                                                                                   
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  198.32       32.17        0.20896E+08                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  1098.0       10933.       11290.       0.0000       123.75       0.0000                                                         
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -15.167       0.0000       0.467                                                                                                 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.85000      822.80       150.00       45880.                                                                                   
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -0.81        -1.14         0.0000      -32.15                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.0          0.0          1.76         0.0000                                                                                   
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.16079      2.0000       0.0000       0.0000       0.0000       0.0000                                                         
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0                                                                                                  
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  79.069       6.1170       14.910                                                                                                
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -14.792       0.0000      0.54000       0.0000                                                                                   
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.143,  -0.0039,   0.0004, 0.0,    0.0,    -0.244,  0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.0245,   1.77,   0.0,    0.00838, 0.0,    0.0                                                                         
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.14,   -0.073,   -9.93,   0.0,    0.0,     0.0,    0.00093                                                                     
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.00212,  0.0,   -0.393,  0.427,   0.0                                                                                 
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.0838, -0.015,    0.0,    0.0,   -12.83,   0.0004, 0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,     0.001,    0.0,    0.184, -1.49,    0.0                                                                                 
                                                                                                                                                                                                                            
Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  4   NO TWD                                                                                                                      
                                                                                                                                                                                                                            
Control Surface No:  1                                                                     Left Flap                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0           30.000     -30.000       +2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.2867       0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7       -2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03 -0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.11893E-02 -0.26625E-02  0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  2                                                                     Right Flap                                                                                                                       
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0           30.000     -30.000       -2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.2867       0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7        2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03  0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.11893E-02 -0.26625E-02 -0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  3                                                                     Left Rudder                                                                                                                      
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000        48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        3.914        0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019        0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333    -3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03  0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.17964E-02 -0.98720E-02 -0.35668E-02   0.0000       0.0000       0.0000                                                        
Control Surface No:  4                                                                     Right Rudder                                                                                                                     
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000       -48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        3.914        0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019       -0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333     3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03 -0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.17964E-02 -0.98720E-02  0.35668E-02   0.0000       0.0000       0.0000                                                        
----------------------------------------------------------------------------------------------------------------------------------------------------------------------                                                                                   
MIXING LOGIC MATRIX DATA .........    (MATRIX TITLE, NAME, VEHICLE TITLE, CONTROL DIRECTIONS)       
Lateral axes Mixing Matrix for Rocket-Plane, Kmix                                                                                         
! This mixing logic uses only four control surfaces for lateral (roll, yaw) control.                                                                                                                                            
! It is based on a vehicle model that does not use the engine and the body-flap                                                                                             
!                                                                                                                                                                                                          
Kmix                                                                                                                                                                                                                        
Rocket Plane at Mach=0.85, Q=150, Rigid Body (for computing the lateral mixing matrix Kmix)                                                                                                                                 
P-dot Roll  Acceleration About X Axis                                                                                                                                                                                       
R-dot Yaw   Acceleration About Z Axis                                                                                                                                                                                       
------------------------------------------------------------------------------------------------------------------------                                                                                                    
SYSTEM OF TRANSFER FUNCTIONS ...                                                                    
First Order Gust Lag                                                                                                                                  
! A low-pass filter 0.5 (rad/sec) to smooth out the input gust                                                                                                                                                              
Continuous                                                                                                                                                                                                                  
TF. Block #  1 First Order Lag                                   Order of Numer, Denom=  0  1                                                                                                                               
Numer 0.0         0.5                                                                                                                                                                                                       
Denom 1.0         0.5                                                                                                                                                                                                       
-------------------------------------------------------------------------------                                                                                                                                             
Block #, from Input #, Gain                                                                                                                                                                                                 
  1  1    1.0                                                                                                                                                                                                               
...........................                                                                                                                                                                                                 
Outpt #, from Block #, Gain                                                                                                                                                                                                 
  1  1    1.0                                                                                                                                                                                                               
...........................                                                                                                                                                                                                 
----------------------------------------------------------------------------------------------------------------------------                                                                                                
SYSTEM OF TRANSFER FUNCTIONS ...                                                                    
Integrator                                                                                                                                            
Continuous                                                                                                                                                                                                                  
TF. Block #  1 First Order Lag                                   Order of Numer, Denom=  0  1                                                                                                                               
Numer 0.0         1.0                                                                                                                                                                                                       
Denom 1.0         0.0                                                                                                                                                                                                       
-------------------------------------------------------------------------------                                                                                                                                             
Block #, from Input #, Gain                                                                                                                                                                                                 
  1  1    1.0                                                                                                                                                                                                               
...........................                                                                                                                                                                                                 
Outpt #, from Block #, Gain                                                                                                                                                                                                 
  1  1    1.0                                                                                                                                                                                                               
...........................                                                                                                                                                                                                 
--------------------------------------------------------------------------------------------------------------------------------------                                                                                           
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (TITLES OF THE NEW AND OLD SYSTEMS)                       
Rocket Plane at Mach=0.85, Q=150, Rigid Body, Lateral Axes                                                                                            
Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                                                                                                
! The lateral axes rigid-body model is extracted from the coupled                                                                                                                                                           
! rigid-body model. The states are: (phi,p, psi,r, and beta)                                                                                                                                                                
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS                                                                                                                                                                  
Extract Inputs :   2   3   4   5   7                                                                                                                                                                                        
Extract States :   1   2   5   6   8                                                                                                                                                                                        
Extract Outputs:   1   2   5   6   8  11  13                                                                                                                                                                                
--------------------------------------------------------------------------------------------------------------------------------------                                                                                      
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (TITLES OF THE NEW AND OLD SYSTEMS)                       
Lateral Design Model                                                                                                                                  
Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                                                                                                
! A further simplified lateral axes system is extracted from the coupled                                                                                                                                          
! rigid-body model to be used for LQR control design. 
! It consists of three states: (p, r, and beta)                                                                              
!                                                                                                                                                                                             
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS                                                                                                                                                                  
Extract Inputs :   2   3   4   5                                                                                                                                                                                            
Extract States :   2   6   8                                                                                                                                                                                                
Extract Outputs:   2   6   8                                                                                                                                                                                                
--------------------------------------------------------------------------------------------------------------------------------------                                                                                      
Step-4 Design a lateral axis controller using LQR                                                                                                                                                                           
--------------------------------------------------------------------------------------------------------------------------------------                                                                                      
INTERCONNECTION OF SYSTEMS .....                                                                    
Lateral Design Model with p-Integral (4-states)                                                                                                       
! The Lateral Axes control design model is augmented with the integral of roll rate.                                                                                                                                        
! The states for LQR design are: (p,r, beta, and p-Integral) 
! The aileron/ rudder Mixing Logic matrix is included in the input 
!                                                                                                          
Titles of Systems to be Combined                                                                                                                                             
Title 1 Lateral Design Model                                                                                                                                                                                                
Title 2 Integrator                                                                                                                                                                                                          
SYSTEM INPUTS TO SUBSYSTEM  1                                                                                                                                                                                               
Via Matrix +Kmix                                                                aileron, rudder                                                                 
..............................................................................                                                                                                                                              
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                All Outputs                                                                                                                                 
Via Matrix +I3                                                                                                                                                                                                              
..............................................................................                                                                                                                                              
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                                                                                                                                                            
System Output  4 from Subsystem  2, Output  1, Gain= 1.0                        p-integral                                                                                                                                  
..............................................................................                                                                                                                                              
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                         Vehicle Beta to Integrator                                                                                                                  
Subsystem  1, Output  1 to Subsystem  2, Input  1, Gain= 1.0                    p-integral                                                                                                                                  
..............................................................................                                                                                                                                              
Definitions of Inputs  =   2                                                                                                                                                                                                
Aileron Deflection (rad)                                                                                                                                                                                                    
Rudder Deflection (rad)                                                                                                                                                                                                     
                                                                                                                                                                                                                            
Definitions of States  =   4                                                                                                                                                                                                
Roll Rate      (p-body)   (rad/sec)                                                                                                                                                                                         
Yaw  Rate      (r-body)   (rad/sec)                                                                                                                                                                                         
Angle of sideslip, beta,  (radian)                                                                                                                                                                                          
p-Integral                (rad)                                                                                                                                                                                             
                                                                                                                                                                                                                            
Definitions of Outputs =   4                                                                                                                                                                                                
Roll Rate      (p-body)   (rad/sec)                                                                                                                                                                                         
Yaw  Rate      (r-body)   (rad/sec)                                                                                                                                                                                         
Angle of sideslip, beta,  (radian)                                                                                                                                                                                          
p-Integral                (rad)                                                                                                                                                                                             
----------------------------------------------------------------------------------------------------------------------------------------                                                                                    
LINEAR QUADRATIC REGULATOR STATE-FEEDBACK CONTROL DESIGN                                                                                                                                                
Lateral LQR Control Design                                                                                                                                                        
Plant Model Used to Design the Control System from:        Lateral Design Model with p-Integral (4-states)                                                                                                                  
Criteria Optimization Output is Matrix C                                                                                                                                                                
State Penalty Weight (Qc) is Matrix:   Qc4                 State Penalty Matrix Qc4                                                                                                                
Control Penalty Weight (Rc) is Matrix: Rc2                 Control Penalty Matrix Rc2                                                                                                                     
Continuous LQR Solution Using Laub Method                                                                                                                                                               
LQR State-Feedback Control Gain Matrix Kpr                 LQR State-Feedback Control for Lateral Axis                                                                                      
--------------------------------------------------------------------------------------------------------------------------------                                                                                            
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Rocket Plane at Mach=0.85, Q=150, Rigid Body                                                                                                          
System                                                                                                                                                                                                                      
Vehi_Coupled_rb.m                                                                                                                                                                                                           
------------------------------------------------------------------------------------------------------------------------                                                                                                    
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Rocket Plane at Mach=0.85, Q=150, Rigid Body, Lateral Axes                                                                                            
System                                                                                                                                                                                                                      
Vehi_rblat.m                                                                                                                                                                                                                
------------------------------------------------------------------------------------------------------------------------                                                                                                    
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Lateral Design Model with p-Integral (4-states)                                                                                                       
System                                                                                                                                                                                                                      
Vehi_Lat_4x.m                                                                                                                                                                                                               
------------------------------------------------------------------------------------------------------------------------                                                                                                    
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Lateral axes Mixing Matrix for Rocket-Plane, Kmix                               
Matrix Kmix                                                                                                                                                                                                                 
------------------------------------------------------------------------------------------------------------------------                                                                                                    
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
LQR State-Feedback Control for Lateral Axis                               
Matrix Kpr                                                                                                                                                                                                               
------------------------------------------------------------------------------------------------------------------------                                                                                                    
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
