BODY FLAP HINGE (ENGINE GIMBAL   70270     0.14532D-02   0.27341D+00   0.15647D-01   0.10699D-01   0.43523D-01  -0.34131D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.14532D-02   0.27341D+00   0.15647D-01   0.10699D-01   0.43523D-01  -0.34131D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01   0.41521D-01   0.47452D-02   0.13802D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01   0.41521D-01   0.47452D-02   0.13802D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01   0.41521D-01   0.47452D-02   0.13802D+00                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.44622D-01   0.20998D+00   0.25057D-01   0.22916D-02  -0.36726D-03  -0.20004D-01                                                                                                
                                                                                                                                                                                                                            
MODE #14/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    240.46       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.30858D-01  -0.30933D-01   0.41221D+00  -0.14163D+00   0.14705D+00   0.23637D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.74871D-01   0.21121D-01   0.38835D+00   0.13520D+00   0.13456D+00  -0.30014D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.79444D-01   0.24622D-01   0.65734D-01   0.64805D-02  -0.12575D+00   0.83713D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.59273D-01   0.19656D-01   0.54761D-01  -0.15535D-01  -0.10329D+00  -0.52758D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34466D-01   0.36712D-01   0.17774D+00   0.43965D-03   0.38563D+00  -0.48072D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34466D-01   0.36712D-01   0.17774D+00   0.43965D-03   0.38563D+00  -0.48072D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.91984D-01   0.28090D-01   0.10084D+00  -0.50378D-02   0.46074D-01  -0.19893D-02                                                                                                
                                                                                                                                                                                                                            
MODE #15/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    259.96       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.62091D-01  -0.10672D-01   0.11528D+00  -0.43441D-01   0.39589D-01   0.88119D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.66919D-01   0.56771D-02   0.12306D+00   0.45957D-01   0.44139D-01  -0.10118D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.18557D-01   0.35438D-02   0.67299D-03   0.53341D-02   0.24303D-02   0.39901D-02                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.19884D-01  -0.10527D-01  -0.15258D-02  -0.48580D-02   0.41044D-02  -0.73538D-02                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.61458D-01  -0.22465D-02   0.47243D-01  -0.59987D-03   0.30357D+00   0.39131D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.61458D-01  -0.22465D-02   0.47243D-01  -0.59987D-03   0.30357D+00   0.39131D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01  -0.94776D-03   0.35347D-01  -0.29673D-02                                                                                                
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01  -0.94776D-03   0.35347D-01  -0.29673D-02                                                                                                
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01  -0.94776D-03   0.35347D-01  -0.29673D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.64209D-02  -0.40493D-02   0.11756D-01   0.24009D-03   0.15884D-01   0.18011D-03                                                                                                
                                                                                                                                                                                                                            
MODE #16/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    297.11       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.33864D-01   0.37649D-01   0.23169D+00  -0.48109D-01   0.14690D+00   0.60390D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.26887D-01   0.57285D-02   0.25111D+00   0.44758D-01   0.13808D+00  -0.87309D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.55412D-02   0.44960D-02   0.38181D-01  -0.36252D-02  -0.22969D-01  -0.48880D-02                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.84483D-02  -0.29883D-02  -0.23369D-01  -0.45596D-02   0.48563D-02  -0.12498D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34332D-04   0.20635D-01   0.20688D-01  -0.98870D-02  -0.10540D+00   0.11896D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34332D-04   0.20635D-01   0.20688D-01  -0.98870D-02  -0.10540D+00   0.11896D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01   0.86668D-02  -0.11380D+00  -0.11858D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01   0.86668D-02  -0.11380D+00  -0.11858D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01   0.86668D-02  -0.11380D+00  -0.11858D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.27217D-01  -0.20243D-02  -0.49614D-02  -0.13521D-01   0.16371D-01  -0.31889D-02                                                                                                
                                                                                                                                                                                                                            
MODE #17/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    317.06       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.11683D+00   0.51829D-01  -0.23021D+00   0.75142D-01  -0.12533D+00   0.69237D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.11013D+00   0.43326D-01   0.34229D+00   0.86069D-01   0.23874D+00   0.68409D-03                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.23572D-01   0.43963D-01  -0.69840D-01   0.15941D-01   0.69693D-01   0.16250D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.98144D-02   0.37857D-01   0.67110D-01   0.16847D-01  -0.57592D-01   0.24501D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10415D-01  -0.59507D-01  -0.38869D-02   0.25894D-01   0.16844D-01   0.12758D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10415D-01  -0.59507D-01  -0.38869D-02   0.25894D-01   0.16844D-01   0.12758D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02   0.49641D-01   0.67975D-01   0.16358D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02   0.49641D-01   0.67975D-01   0.16358D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02   0.49641D-01   0.67975D-01   0.16358D+00                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.30818D-01   0.25622D-01   0.41221D-01   0.17267D-01   0.29466D-02   0.16911D-01                                                                                                
                                                                                                                                                                                                                            
MODE #18/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    319.80       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.50196D-01  -0.40789D-01  -0.38652D+00   0.12459D-01  -0.44580D+00  -0.87010D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.38709D-01   0.40601D-01  -0.28800D+00   0.10989D-01  -0.37014D+00   0.19376D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.48973D-01   0.31855D-02   0.49316D-01   0.12474D-01  -0.63510D-01   0.55286D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.53112D-01   0.40017D-01   0.70281D-01  -0.66606D-02  -0.82421D-01  -0.31104D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.71547D-01   0.54607D-02   0.10848D+00   0.44828D-02  -0.43449D+00  -0.18257D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.71547D-01   0.54607D-02   0.10848D+00   0.44828D-02  -0.43449D+00  -0.18257D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.12443D+00   0.12328D-01   0.10169D+00   0.53511D-02   0.74090D-02   0.21169D-01                                                                                                
                                                                                                                                                                                                                            
MODE #19/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    331.28       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.87552D-01  -0.26330D-01   0.59045D-02  -0.39502D-01  -0.93514D-01   0.80926D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.87060D-01   0.12492D-01  -0.40659D-01   0.24659D-01  -0.12282D+00  -0.50523D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.11650D-01   0.10751D-01   0.66156D-01   0.10817D-01  -0.27441D-01   0.16791D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.14078D-01  -0.51422D-02   0.44575D-01  -0.14211D-01  -0.13102D-01  -0.15636D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.40971D-01   0.13070D-01   0.91515D-01  -0.35541D-02  -0.35166D+00  -0.19143D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.40971D-01   0.13070D-01   0.91515D-01  -0.35541D-02  -0.35166D+00  -0.19143D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.13403D-01   0.37829D-03   0.69875D-01   0.19023D-02   0.12148D-01   0.42055D-03                                                                                                
                                                                                                                                                                                                                            
MODE #20/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    338.12       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.16520D+00   0.38899D-01   0.89818D-01  -0.13882D-01   0.10877D+00  -0.19167D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.58278D-01  -0.16687D-02   0.28248D-01  -0.85748D-03   0.46491D-01   0.29172D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.31651D-01  -0.29139D-01  -0.26383D-01   0.27623D-02  -0.26053D-02   0.13570D-02                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.34605D-01  -0.22298D-01  -0.30291D-01  -0.67459D-02   0.21949D-02  -0.30795D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.48754D-01  -0.21776D-01  -0.15673D-01  -0.20327D-02   0.33889D-01   0.38638D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.48754D-01  -0.21776D-01  -0.15673D-01  -0.20327D-02   0.33889D-01   0.38638D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02  -0.61511D-02   0.14494D+00   0.67076D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02  -0.61511D-02   0.14494D+00   0.67076D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02  -0.61511D-02   0.14494D+00   0.67076D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.63408D-01  -0.30692D-01  -0.28472D-02  -0.29323D-01   0.33512D-01   0.28261D-01                                                                                                
                                                                                                                                                                                                                            
MODE #21/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    359.54       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.41184D+00   0.54617D-01  -0.45819D-01  -0.21406D-01  -0.14563D+00  -0.66295D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.40355D+00  -0.43448D-01   0.61745D-02   0.30384D-01  -0.85559D-01   0.60470D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.92831D-01  -0.27625D-01  -0.19442D-02  -0.13571D-01  -0.66657D-01   0.22992D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.91628D-01   0.23680D-01   0.16386D-01   0.14687D-01  -0.73300D-01  -0.21622D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11383D+00  -0.58277D-02   0.90839D-01   0.25959D-02  -0.47449D-01   0.71110D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11383D+00  -0.58277D-02   0.90839D-01   0.25959D-02  -0.47449D-01   0.71110D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03                                                                                                
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03                                                                                                
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.18130D+00   0.40456D-02   0.32554D-01   0.41406D-02   0.33371D-01  -0.47347D-04                                                                                                
                                                                                                                                                                                                                            
MODE #22/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    359.89       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.13928D+00   0.17836D-01  -0.95513D-01   0.93761D-02  -0.78782D-01  -0.26915D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.15501D+00  -0.19435D-01  -0.69515D-01  -0.47754D-02  -0.50925D-01   0.27986D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.26797D-01  -0.38884D-02  -0.13625D-01  -0.78677D-02  -0.13237D-01   0.27622D-02                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.25528D-01   0.85973D-02  -0.76898D-02   0.85163D-02  -0.15341D-01   0.99894D-03                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.40331D-01   0.13277D-02   0.18228D-02   0.10260D-02   0.59038D-01  -0.37225D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.40331D-01   0.13277D-02   0.18228D-02   0.10260D-02   0.59038D-01  -0.37225D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02                                                                                                
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02                                                                                                
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.43469D-01   0.56260D-02  -0.12023D-01   0.24928D-03   0.78490D-02  -0.21047D-02                                                                                                
--------------------------------------------------------------------------------------------------------------------------------                                                                                            
SELECTED MODAL DATA AND LOCATIONS FOR MIXED AXES MODES                                              
Rocket Plane at Mach=0.85, Q=150, Flex Model, (30 Mixed Modes)                                                                                        
! Select 30 flex modes from all three, roll, pitch, and yaw axes                                                                                                                                                            
! Run the mode selection program to select 30 modes from all directions using the modal data                                                                                                                                
! file (RocketPlane.Mod) using the the Node locations from file (RocketPlane.Nod), Select                                                                                                                                   
! 4 force excitation points at the center of the four control surfaces with the force                                                                                                                                       
! directions along z.                                                                                                                                                                                                       
! Select 2 torque excitation points at the two rudders and apply pitch moments,                                                                                                                                             
! Select 2 translation sensor points at the left and right nav bases sensing along the z                                                                                                                                    
! axis. Select 1 rotational sensor point at the center nav base sensing pitch rotations.                                                                                                                                    
! Then using the node map menu identify the locations of the four control surfaces, the                                                                                                                                     
! engine, the 3 gyros, the accelerometers, and one disturbance point in case that you                                                                                                                                       
! want to apply an excitation force in the (A,B,C,D) model                                                                                                                                                                  
                                                                                                                                                                                                                            
MODE # 1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.168       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.88837D-01   0.80693D-01  -0.31931D+00   0.55369D-01  -0.15543D-01   0.10639D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.90890D-01   0.80487D-01   0.32028D+00   0.54879D-01   0.15552D-01   0.10600D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.11619D+00   0.11498D+00  -0.20924D+00   0.70946D-01  -0.21047D-01   0.19172D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.11864D+00   0.11503D+00   0.21196D+00   0.71042D-01   0.21263D-01   0.19094D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11188D-02  -0.16957D+00   0.13759D-02   0.61874D-01   0.41981D-04   0.28465D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11188D-02  -0.16957D+00   0.13759D-02   0.61874D-01   0.41981D-04   0.28465D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02  -0.12250D+00   0.42723D-03   0.65102D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02  -0.12250D+00   0.42723D-03   0.65102D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02  -0.12250D+00   0.42723D-03   0.65102D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.65461D-01   0.75161D-01   0.12025D+00   0.57916D-01   0.14990D-02   0.32534D-01                                                                                                
                                                                                                                                                                                                                            
MODE # 2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    80.049       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.11504D-01  -0.90746D-02   0.29126D+00  -0.32992D-01  -0.44843D-01   0.41524D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.97675D-02   0.47826D-02   0.29436D+00   0.33689D-01  -0.44658D-01  -0.44089D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.17314D+00   0.11315D-01  -0.24336D+00   0.17891D-01  -0.92933D-01  -0.15111D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.17467D+00  -0.11194D-01  -0.24153D+00  -0.17202D-01  -0.92692D-01   0.14310D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.49436D-01  -0.45508D-03  -0.33501D+00   0.24732D-03  -0.73365D-01  -0.21098D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.49436D-01  -0.45508D-03  -0.33501D+00   0.24732D-03  -0.73365D-01  -0.21098D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03                                                                                                
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03                                                                                                
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.14718D+00   0.30794D-03  -0.26919D+00   0.17007D-03  -0.56907D-01  -0.18184D-02                                                                                                
                                                                                                                                                                                                                            
MODE # 3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    106.21       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.76552D-02  -0.92385D-01   0.13606D+01  -0.34666D+00   0.63093D-01   0.11104D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.92521D-02   0.90141D-01   0.13309D+01   0.33951D+00   0.62679D-01  -0.11157D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.22391D-01   0.86309D-02  -0.20600D-01   0.86376D-02  -0.40299D-02  -0.16314D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.20824D-01   0.16819D-02  -0.15456D-01  -0.45419D-02  -0.35437D-03   0.11148D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.47210D-03   0.23624D-02  -0.69842D-02   0.51743D-03   0.12643D-01  -0.24013D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.47210D-03   0.23624D-02  -0.69842D-02   0.51743D-03   0.12643D-01  -0.24013D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04                                                                                                
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04                                                                                                
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.10890D-01   0.24190D-02  -0.10459D-01   0.29842D-02  -0.13584D-03   0.25432D-02                                                                                                
                                                                                                                                                                                                                            
MODE # 4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    117.76       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.15061D-01   0.16560D+00  -0.95724D+00   0.23160D+00  -0.26275D-01  -0.66365D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.12838D-01   0.16971D+00   0.10226D+01   0.24805D+00   0.29250D-01  -0.76581D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.26032D-01  -0.24549D+00   0.21762D+00  -0.19380D+00   0.20743D+00   0.25555D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.24370D-01  -0.24715D+00  -0.22345D+00  -0.19597D+00  -0.21114D+00   0.25847D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.16584D-03   0.79641D-02  -0.26760D-02  -0.38358D-01  -0.54629D-03   0.10822D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.16584D-03   0.79641D-02  -0.26760D-02  -0.38358D-01  -0.54629D-03   0.10822D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02   0.21564D-02  -0.37031D-03   0.10835D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02   0.21564D-02  -0.37031D-03   0.10835D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02   0.21564D-02  -0.37031D-03   0.10835D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.12094D-01  -0.12761D+00  -0.63818D-01  -0.22036D-01  -0.66178D-02   0.39445D-02                                                                                                
                                                                                                                                                                                                                            
MODE # 5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.08       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.97636D-02   0.33171D-02  -0.32694D-01   0.11974D-01   0.77802D-02   0.15581D-03                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.87838D-02  -0.17282D-02  -0.33354D-01  -0.12079D-01   0.76386D-02   0.27519D-04                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.18589D-01   0.26137D+00  -0.12665D+00   0.31476D+00  -0.41941D+00  -0.51425D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.19071D-01  -0.25614D+00  -0.12360D+00  -0.30882D+00  -0.41088D+00   0.50430D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.97709D-02   0.13981D-03   0.79409D-01  -0.88189D-04   0.24807D-01   0.27542D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.97709D-02   0.13981D-03   0.79409D-01  -0.88189D-04   0.24807D-01   0.27542D-04                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03                                                                                                
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03                                                                                                
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.13888D-01  -0.18176D-01   0.89578D-01   0.31518D-01  -0.82099D-04  -0.35170D-02                                                                                                
                                                                                                                                                                                                                            
MODE # 6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    139.89       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.17941D+00   0.72041D-01   0.33542D+00  -0.78973D-01   0.31461D-01   0.34968D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.16966D+00   0.76975D-01  -0.23760D+00  -0.56332D-01  -0.26670D-01   0.31703D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.18338D+00  -0.35546D-01  -0.10370D+00   0.15024D+00  -0.26848D+00  -0.17864D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.17382D+00  -0.30012D-01   0.96662D-01   0.15712D+00   0.27341D+00  -0.19498D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.96048D-03  -0.21118D+00  -0.74715D-02   0.91171D-03  -0.34525D-02   0.30360D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.96048D-03  -0.21118D+00  -0.74715D-02   0.91171D-03  -0.34525D-02   0.30360D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.61213D-01  -0.16998D+00  -0.12219D-01  -0.95908D-02   0.44280D-02   0.34914D-01                                                                                                
                                                                                                                                                                                                                            
MODE # 7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    144.36       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.10313D+00   0.59976D-01  -0.92321D+00   0.24665D+00  -0.58141D-01  -0.28657D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.10084D+00   0.58624D-01   0.88260D+00   0.23939D+00   0.55242D-01  -0.27078D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.14699D+00   0.69855D-01   0.10645D+00   0.14526D+00  -0.25342D+00  -0.42415D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.15481D+00   0.73395D-01  -0.11367D+00   0.14950D+00   0.25655D+00  -0.43475D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10862D-02   0.17274D+00  -0.56238D-02  -0.73630D-01  -0.18669D-02  -0.20976D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10862D-02   0.17274D+00  -0.56238D-02  -0.73630D-01  -0.18669D-02  -0.20976D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02  -0.48928D-01   0.20260D-02  -0.20227D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02  -0.48928D-01   0.20260D-02  -0.20227D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02  -0.48928D-01   0.20260D-02  -0.20227D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.49417D-01  -0.68279D-01  -0.16146D+00  -0.90131D-01   0.14827D-02  -0.22316D-01                                                                                                
                                                                                                                                                                                                                            
MODE # 8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    152.20       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.62364D-01   0.30843D-01  -0.57249D+00   0.11734D+00  -0.31447D-01  -0.24464D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.90041D-01  -0.18808D-01  -0.62485D+00  -0.13148D+00  -0.36842D-01   0.29835D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.26735D-01   0.40879D-02   0.21715D-01   0.14748D-01   0.42806D-02  -0.36604D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.67547D-01  -0.17020D-01   0.37646D-01  -0.99377D-02   0.20595D-01   0.53115D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.22799D-01  -0.18308D-01   0.58843D-01   0.23209D-02   0.35487D-01   0.27840D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.22799D-01  -0.18308D-01   0.58843D-01   0.23209D-02   0.35487D-01   0.27840D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00   0.16418D-02   0.80898D-01   0.29896D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00   0.16418D-02   0.80898D-01   0.29896D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00   0.16418D-02   0.80898D-01   0.29896D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00                                                                                                                                          
                                                                                                                                                                                                                            
