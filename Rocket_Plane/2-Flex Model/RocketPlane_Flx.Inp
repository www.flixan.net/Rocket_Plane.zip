                                                                                                                                                                                                                            
MODE #27/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    354.65       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.20176D+00   0.99058D-01  -0.27706D+00   0.56835D-01  -0.21717D+00  -0.50026D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.14503D+00   0.63918D-01   0.28154D+00   0.78221D-01   0.32272D+00  -0.26553D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.29846D-01  -0.56684D-01  -0.17300D+00   0.14028D-01   0.64816D-01   0.67630D-02                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.30522D-01  -0.43305D-01   0.14627D+00   0.34455D-01  -0.97934D-01   0.58261D-02                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.45761D-01  -0.16354D+00   0.15815D-02   0.45868D-01   0.78517D-01   0.19797D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.45761D-01  -0.16354D+00   0.15815D-02   0.45868D-01   0.78517D-01   0.19797D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01   0.46568D-01  -0.65990D+00   0.77592D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01   0.46568D-01  -0.65990D+00   0.77592D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01   0.46568D-01  -0.65990D+00   0.77592D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.97404D-01  -0.39042D-01   0.75517D-01   0.43327D-01   0.70055D-02   0.17325D-01                                                                                                
                                                                                                                                                                                                                            
MODE #28/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    354.97       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.17881D+00   0.55608D-01  -0.26189D+00   0.72775D-01  -0.31685D+00   0.25117D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.26079D+00   0.10218D+00   0.25197D+00   0.51321D-01   0.18540D+00  -0.57244D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.39474D-01  -0.42542D-01  -0.12385D+00   0.35946D-01   0.93972D-01   0.28532D-02                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.37813D-01  -0.62310D-01   0.16908D+00   0.94209D-02  -0.56336D-01   0.28403D-02                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.60006D-01  -0.15826D+00   0.81637D-02   0.41502D-01  -0.11770D+00   0.19394D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.60006D-01  -0.15826D+00   0.81637D-02   0.41502D-01  -0.11770D+00   0.19394D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01   0.40425D-01   0.67617D+00   0.83151D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01   0.40425D-01   0.67617D+00   0.83151D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01   0.40425D-01   0.67617D+00   0.83151D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.18472D-01  -0.50836D-01   0.11544D+00   0.40524D-01  -0.11895D-01   0.23948D-01                                                                                                
                                                                                                                                                                                                                            
MODE #29/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    359.54       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.41184D+00   0.54617D-01  -0.45819D-01  -0.21406D-01  -0.14563D+00  -0.66295D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.40355D+00  -0.43448D-01   0.61745D-02   0.30384D-01  -0.85559D-01   0.60470D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.92831D-01  -0.27625D-01  -0.19442D-02  -0.13571D-01  -0.66657D-01   0.22992D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.91628D-01   0.23680D-01   0.16386D-01   0.14687D-01  -0.73300D-01  -0.21622D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11383D+00  -0.58277D-02   0.90839D-01   0.25959D-02  -0.47449D-01   0.71110D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11383D+00  -0.58277D-02   0.90839D-01   0.25959D-02  -0.47449D-01   0.71110D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03                                                                                                
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03                                                                                                
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.18130D+00   0.40456D-02   0.32554D-01   0.41406D-02   0.33371D-01  -0.47347D-04                                                                                                
                                                                                                                                                                                                                            
MODE #30/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    359.89       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.13928D+00   0.17836D-01  -0.95513D-01   0.93761D-02  -0.78782D-01  -0.26915D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.15501D+00  -0.19435D-01  -0.69515D-01  -0.47754D-02  -0.50925D-01   0.27986D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.26797D-01  -0.38884D-02  -0.13625D-01  -0.78677D-02  -0.13237D-01   0.27622D-02                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.25528D-01   0.85973D-02  -0.76898D-02   0.85163D-02  -0.15341D-01   0.99894D-03                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.40331D-01   0.13277D-02   0.18228D-02   0.10260D-02   0.59038D-01  -0.37225D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.40331D-01   0.13277D-02   0.18228D-02   0.10260D-02   0.59038D-01  -0.37225D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02                                                                                                
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02                                                                                                
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.43469D-01   0.56260D-02  -0.12023D-01   0.24928D-03   0.78490D-02  -0.21047D-02                                                                                                
----------------------------------------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : NewName   
Rocket Plane at Mach=0.85, Q=150, Flex Model, NewName             

MODE#  1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.168       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.88837D-01   0.80693D-01  -0.31931D+00   0.55369D-01  -0.15543D-01   0.10639D-01
RIGHT FLAP CENTER               160243    -0.72807D-01   0.73610D-01   0.23721D+00   0.55374D-01   0.15310D-01   0.10679D-01
LEFT RUDDER HINGE LINE POINT     81441     0.11619D+00   0.11498D+00  -0.20924D+00   0.70946D-01  -0.21047D-01   0.19172D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.11864D+00   0.11503D+00   0.21196D+00   0.71042D-01   0.21263D-01   0.19094D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11188D-02  -0.16957D+00   0.13759D-02   0.61874D-01   0.41981D-04   0.28465D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11188D-02  -0.16957D+00   0.13759D-02   0.61874D-01   0.41981D-04   0.28465D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02  -0.12250D+00   0.42723D-03   0.65102D-01
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02  -0.12250D+00   0.42723D-03   0.65102D-01
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02  -0.12250D+00   0.42723D-03   0.65102D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.11273D-02  -0.17848D+00   0.14055D-02   0.60233D-01   0.43181D-04   0.31345D-01

MODE#  2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    80.049       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.11504D-01  -0.90746D-02   0.29126D+00  -0.32992D-01  -0.44843D-01   0.41524D-02
RIGHT FLAP CENTER               160243    -0.17260D-01   0.68560D-02   0.21260D+00   0.34837D-01  -0.44946D-01  -0.37668D-02
LEFT RUDDER HINGE LINE POINT     81441     0.17314D+00   0.11315D-01  -0.24336D+00   0.17891D-01  -0.92933D-01  -0.15111D-01
RIGHT RUDDER HINGE LINE POINT   181441     0.17467D+00  -0.11194D-01  -0.24153D+00  -0.17202D-01  -0.92692D-01   0.14310D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.49436D-01  -0.45508D-03  -0.33501D+00   0.24732D-03  -0.73365D-01  -0.21098D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.49436D-01  -0.45508D-03  -0.33501D+00   0.24732D-03  -0.73365D-01  -0.21098D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.34638D-01  -0.26169D-03  -0.38631D+00   0.24441D-03  -0.74304D-01  -0.20916D-03

MODE#  3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    106.21       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.76552D-02  -0.92385D-01   0.13606D+01  -0.34666D+00   0.63093D-01   0.11104D-01
RIGHT FLAP CENTER               160243    -0.34292D-02   0.91512D-01   0.79675D+00   0.34584D+00   0.59172D-01  -0.65625D-02
LEFT RUDDER HINGE LINE POINT     81441    -0.22391D-01   0.86309D-02  -0.20600D-01   0.86376D-02  -0.40299D-02  -0.16314D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.20824D-01   0.16819D-02  -0.15456D-01  -0.45419D-02  -0.35437D-03   0.11148D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.47210D-03   0.23624D-02  -0.69842D-02   0.51743D-03   0.12643D-01  -0.24013D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.47210D-03   0.23624D-02  -0.69842D-02   0.51743D-03   0.12643D-01  -0.24013D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.29957D-02   0.27017D-02   0.18019D-02   0.58901D-03   0.12689D-01  -0.38756D-03

MODE#  4/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.08       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.97636D-02   0.33171D-02  -0.32694D-01   0.11974D-01   0.77802D-02   0.15581D-03
RIGHT FLAP CENTER               160243     0.87234D-02  -0.15736D-02  -0.88399D-02  -0.12241D-01   0.77870D-02  -0.21514D-03
LEFT RUDDER HINGE LINE POINT     81441    -0.18589D-01   0.26137D+00  -0.12665D+00   0.31476D+00  -0.41941D+00  -0.51425D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.19071D-01  -0.25614D+00  -0.12360D+00  -0.30882D+00  -0.41088D+00   0.50430D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.97709D-02   0.13981D-03   0.79409D-01  -0.88189D-04   0.24807D-01   0.27542D-04

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.97709D-02   0.13981D-03   0.79409D-01  -0.88189D-04   0.24807D-01   0.27542D-04

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298     0.46858D-02   0.10599D-03   0.96915D-01  -0.84568D-04   0.25468D-01   0.23367D-04

MODE#  5/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    139.89       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.17941D+00   0.72041D-01   0.33542D+00  -0.78973D-01   0.31461D-01   0.34968D-01
RIGHT FLAP CENTER               160243    -0.11857D+00   0.59850D-01  -0.15779D+00  -0.58460D-01  -0.25579D-01   0.30509D-01
LEFT RUDDER HINGE LINE POINT     81441     0.18338D+00  -0.35546D-01  -0.10370D+00   0.15024D+00  -0.26848D+00  -0.17864D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.17382D+00  -0.30012D-01   0.96662D-01   0.15712D+00   0.27341D+00  -0.19498D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.96048D-03  -0.21118D+00  -0.74715D-02   0.91171D-03  -0.34525D-02   0.30360D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.96048D-03  -0.21118D+00  -0.74715D-02   0.91171D-03  -0.34525D-02   0.30360D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.25492D-03  -0.24256D+00  -0.99032D-02  -0.10177D-01  -0.35346D-02   0.52145D-01

MODE#  6/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    144.36       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.10313D+00   0.59976D-01  -0.92321D+00   0.24665D+00  -0.58141D-01  -0.28657D-01
RIGHT FLAP CENTER               160243     0.62121D-01   0.70808D-01   0.51139D+00   0.24653D+00   0.50762D-01  -0.21963D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.14699D+00   0.69855D-01   0.10645D+00   0.14526D+00  -0.25342D+00  -0.42415D+00
RIGHT RUDDER HINGE LINE POINT   181441     0.15481D+00   0.73395D-01  -0.11367D+00   0.14950D+00   0.25655D+00  -0.43475D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10862D-02   0.17274D+00  -0.56238D-02  -0.73630D-01  -0.18669D-02  -0.20976D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10862D-02   0.17274D+00  -0.56238D-02  -0.73630D-01  -0.18669D-02  -0.20976D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02  -0.48928D-01   0.20260D-02  -0.20227D-01
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02  -0.48928D-01   0.20260D-02  -0.20227D-01
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02  -0.48928D-01   0.20260D-02  -0.20227D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298     0.14695D-02   0.18016D+00  -0.69428D-02  -0.65075D-01  -0.19201D-02  -0.35441D-01

MODE#  7/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    152.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.62364D-01   0.30843D-01  -0.57249D+00   0.11734D+00  -0.31447D-01  -0.24464D-01
RIGHT FLAP CENTER               160243    -0.44298D-01  -0.34123D-01  -0.42389D+00  -0.13782D+00  -0.33722D-01   0.26768D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.26735D-01   0.40879D-02   0.21715D-01   0.14748D-01   0.42806D-02  -0.36604D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.67547D-01  -0.17020D-01   0.37646D-01  -0.99377D-02   0.20595D-01   0.53115D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.22799D-01  -0.18308D-01   0.58843D-01   0.23209D-02   0.35487D-01   0.27840D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.22799D-01  -0.18308D-01   0.58843D-01   0.23209D-02   0.35487D-01   0.27840D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00   0.16418D-02   0.80898D-01   0.29896D-02
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00   0.16418D-02   0.80898D-01   0.29896D-02
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00   0.16418D-02   0.80898D-01   0.29896D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298     0.15529D-01  -0.20821D-01   0.83867D-01   0.11996D-02   0.36398D-01   0.49163D-02

MODE#  8/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    174.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.11413D-01  -0.17332D-01   0.28337D-01  -0.10856D-01  -0.13600D-01   0.33386D-02
RIGHT FLAP CENTER               160243    -0.89128D-02  -0.40497D-02   0.31817D-01   0.30416D-01  -0.97433D-02  -0.33430D-03
LEFT RUDDER HINGE LINE POINT     81441    -0.50040D+00  -0.14653D-01   0.13047D+00   0.25444D-01   0.26962D+00  -0.33121D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.56425D+00  -0.41249D-01   0.12007D+00  -0.80971D-02   0.34310D+00   0.32645D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.25698D-01  -0.23582D-01   0.21006D+00  -0.42739D-02   0.25229D+00   0.17062D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.25698D-01  -0.23582D-01   0.21006D+00  -0.42739D-02   0.25229D+00   0.17062D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01   0.38503D-03  -0.66226D-02   0.30360D-02
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01   0.38503D-03  -0.66226D-02   0.30360D-02
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01   0.38503D-03  -0.66226D-02   0.30360D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.25879D-01  -0.27520D-01   0.38773D+00  -0.62358D-02   0.25831D+00   0.57246D-02

MODE#  9/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    187.74       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.56989D-01  -0.30457D-01  -0.15421D+00   0.66675D-01   0.17176D-02  -0.60231D-02
RIGHT FLAP CENTER               160243    -0.37160D-01  -0.49041D-01  -0.50520D-02  -0.24262D-01   0.18424D-02   0.14843D-02
LEFT RUDDER HINGE LINE POINT     81441     0.51235D+00  -0.10033D+00   0.37524D-01   0.68871D-03  -0.41041D+00   0.22164D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.98215D-01  -0.48668D-01  -0.17903D-01   0.28621D-01   0.10793D+00   0.48358D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.37672D-01  -0.11493D-01  -0.33126D-01  -0.11908D-01  -0.10259D+00  -0.20928D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.37672D-01  -0.11493D-01  -0.33126D-01  -0.11908D-01  -0.10259D+00  -0.20928D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00   0.88085D-02   0.15483D-01   0.46816D-02
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00   0.88085D-02   0.15483D-01   0.46816D-02
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00   0.88085D-02   0.15483D-01   0.46816D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.16702D-01  -0.13641D-01  -0.10534D+00  -0.13046D-01  -0.10498D+00   0.66677D-03

MODE# 10/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    191.66       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.10524D-01   0.16953D-01  -0.80601D-01   0.37195D-01  -0.67365D-02   0.64142D-02
RIGHT FLAP CENTER               160243    -0.81666D-01  -0.68288D-02  -0.19844D-01  -0.57159D-01   0.43547D-02   0.11935D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.25575D+00  -0.13894D-01  -0.11109D-01  -0.14241D-01   0.20337D+00  -0.17917D+00
RIGHT RUDDER HINGE LINE POINT   181441     0.48296D+00   0.40397D-01   0.46021D-01   0.17247D-01  -0.37775D+00  -0.23326D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.34377D-01  -0.71635D-01  -0.21858D-01   0.58121D-02  -0.77920D-01   0.92247D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.34377D-01  -0.71635D-01  -0.21858D-01   0.58121D-02  -0.77920D-01   0.92247D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00  -0.73553D-02   0.15726D-01   0.14277D-01
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00  -0.73553D-02   0.15726D-01   0.14277D-01
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00  -0.73553D-02   0.15726D-01   0.14277D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.18431D-01  -0.83549D-01  -0.76737D-01  -0.13153D-02  -0.79805D-01   0.22975D-01

MODE# 11/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    204.74       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.82904D-01   0.19357D+00   0.69557D-01  -0.15632D-01   0.29545D-01  -0.10975D-01
RIGHT FLAP CENTER               160243     0.33027D-01   0.19662D+00  -0.60996D-01  -0.19021D-01  -0.36332D-01  -0.11931D-01
LEFT RUDDER HINGE LINE POINT     81441     0.10391D+00   0.61041D-01   0.66399D-01  -0.36144D-01  -0.95861D-01   0.32148D-02
RIGHT RUDDER HINGE LINE POINT   181441    -0.20580D+00   0.89700D-01  -0.14047D+00  -0.51936D-02   0.18234D+00   0.91732D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.15959D-01   0.19006D+00  -0.67413D-01  -0.27661D-01  -0.11643D+00  -0.22682D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.15959D-01   0.19006D+00  -0.67413D-01  -0.27661D-01  -0.11643D+00  -0.22682D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01   0.53021D-01   0.62357D-02  -0.10971D+00
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01   0.53021D-01   0.62357D-02  -0.10971D+00
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01   0.53021D-01   0.62357D-02  -0.10971D+00

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298     0.80202D-02   0.20398D+00  -0.14973D+00  -0.81779D-02  -0.11992D+00  -0.37869D-01

MODE# 12/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    212.28       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.83480D-01   0.81759D-01  -0.15687D+00   0.54831D-01   0.95507D-02   0.56544D-02
RIGHT FLAP CENTER               160243    -0.62819D-01   0.74669D-01   0.12513D-01   0.28974D-01   0.86980D-02   0.16510D-01
LEFT RUDDER HINGE LINE POINT     81441     0.10642D+00  -0.12391D+00   0.27646D+00   0.54135D-01  -0.18107D+00  -0.79518D-01
RIGHT RUDDER HINGE LINE POINT   181441     0.25123D+00  -0.16154D+00   0.16471D-02  -0.11191D-01  -0.14295D+00  -0.30636D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37463D-01  -0.72375D-01   0.22229D+00  -0.58679D-01   0.37922D+00   0.21313D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37463D-01  -0.72375D-01   0.22229D+00  -0.58679D-01   0.37922D+00   0.21313D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01   0.84312D-01   0.14697D-01  -0.29894D-01
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01   0.84312D-01   0.14697D-01  -0.29894D-01
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01   0.84312D-01   0.14697D-01  -0.29894D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.40838D-01  -0.11170D+00   0.49078D+00  -0.70964D-01   0.39142D+00   0.50703D-01

MODE# 13/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    213.34       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.82634D-01  -0.14071D-01  -0.15927D-01   0.12720D-02   0.32561D-01  -0.15804D-01
RIGHT FLAP CENTER               160243     0.33018D-01  -0.16197D-01  -0.76536D-01  -0.72573D-01   0.16634D-01   0.13579D-02
LEFT RUDDER HINGE LINE POINT     81441     0.22007D+00   0.11137D+00   0.55177D-01   0.71670D-02  -0.13803D+00   0.20623D+00
RIGHT RUDDER HINGE LINE POINT   181441     0.10907D+00   0.94893D-01   0.20621D+00  -0.39364D-01  -0.14707D+00   0.37735D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37273D-01   0.66994D-01   0.19565D+00   0.33901D-01   0.33495D+00  -0.12356D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37273D-01   0.66994D-01   0.19565D+00   0.33901D-01   0.33495D+00  -0.12356D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01  -0.49634D-01   0.36590D-01  -0.50653D-02
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01  -0.49634D-01   0.36590D-01  -0.50653D-02
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01  -0.49634D-01   0.36590D-01  -0.50653D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.31921D-01   0.92573D-01   0.43286D+00   0.43994D-01   0.34585D+00  -0.35147D-01

MODE# 14/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    217.34       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.40299D-02   0.19201D-02   0.53943D-01  -0.19972D-01  -0.31820D-01  -0.15372D-03
RIGHT FLAP CENTER               160243     0.34811D-01   0.18729D-02  -0.36343D-01  -0.13249D-01  -0.40814D-01  -0.63338D-02
LEFT RUDDER HINGE LINE POINT     81441     0.24933D+00   0.64744D-01   0.17729D+00   0.34012D-01  -0.22368D+00   0.19362D+00
RIGHT RUDDER HINGE LINE POINT   181441     0.20682D+00   0.27358D-01   0.23834D+00  -0.47408D-01  -0.22941D+00  -0.95107D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.31758D-01   0.31171D-01   0.32350D+00   0.13782D-01   0.57805D+00  -0.50773D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.31758D-01   0.31171D-01   0.32350D+00   0.13782D-01   0.57805D+00  -0.50773D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01  -0.21513D-01  -0.19543D-01  -0.97179D-02
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01  -0.21513D-01  -0.19543D-01  -0.97179D-02
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01  -0.21513D-01  -0.19543D-01  -0.97179D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.87725D-01   0.42237D-01   0.73300D+00   0.18538D-01   0.59717D+00  -0.15675D-01

MODE# 15/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    240.46       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.30858D-01  -0.30933D-01   0.41221D+00  -0.14163D+00   0.14705D+00   0.23637D-01
RIGHT FLAP CENTER               160243     0.32294D-01   0.36452D-01   0.23631D+00   0.14177D+00   0.12766D+00  -0.25486D-01
LEFT RUDDER HINGE LINE POINT     81441     0.79444D-01   0.24622D-01   0.65734D-01   0.64805D-02  -0.12575D+00   0.83713D-01
RIGHT RUDDER HINGE LINE POINT   181441     0.59273D-01   0.19656D-01   0.54761D-01  -0.15535D-01  -0.10329D+00  -0.52758D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34466D-01   0.36712D-01   0.17774D+00   0.43965D-03   0.38563D+00  -0.48072D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34466D-01   0.36712D-01   0.17774D+00   0.43965D-03   0.38563D+00  -0.48072D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.45838D-01   0.46045D-01   0.45201D+00   0.66494D-02   0.40078D+00  -0.17276D-01

MODE# 16/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    259.96       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.62091D-01  -0.10672D-01   0.11528D+00  -0.43441D-01   0.39589D-01   0.88119D-02
RIGHT FLAP CENTER               160243     0.52471D-01   0.10785D-01   0.70714D-01   0.47991D-01   0.41478D-01  -0.88417D-02
LEFT RUDDER HINGE LINE POINT     81441     0.18557D-01   0.35438D-02   0.67299D-03   0.53341D-02   0.24303D-02   0.39901D-02
RIGHT RUDDER HINGE LINE POINT   181441     0.19884D-01  -0.10527D-01  -0.15258D-02  -0.48580D-02   0.41044D-02  -0.73538D-02
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.61458D-01  -0.22465D-02   0.47243D-01  -0.59987D-03   0.30357D+00   0.39131D-04

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.61458D-01  -0.22465D-02   0.47243D-01  -0.59987D-03   0.30357D+00   0.39131D-04

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01  -0.94776D-03   0.35347D-01  -0.29673D-02
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01  -0.94776D-03   0.35347D-01  -0.29673D-02
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01  -0.94776D-03   0.35347D-01  -0.29673D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.18991D-02  -0.28363D-02   0.26331D+00  -0.10508D-02   0.31593D+00   0.99337D-03

MODE# 17/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    284.87       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.29083D-01   0.22437D-02  -0.74861D-01   0.10138D-01  -0.79587D-01  -0.68494D-02
RIGHT FLAP CENTER               160243    -0.30812D-01  -0.72043D-02  -0.10006D+00  -0.13303D-01  -0.78617D-01   0.94859D-02
LEFT RUDDER HINGE LINE POINT     81441    -0.25307D-01  -0.33395D-01  -0.18924D+00  -0.20924D-01   0.64764D-01  -0.12383D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.24861D-01   0.20294D-01  -0.19767D+00   0.20380D-01   0.69834D-01   0.39998D-02
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.76711D-01  -0.27874D-02  -0.39887D-01  -0.18478D-02   0.31621D+01   0.63559D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.76711D-01  -0.27874D-02  -0.39887D-01  -0.18478D-02   0.31621D+01   0.63559D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.67905D-02   0.11363D-02  -0.51737D-01   0.28808D-02   0.19426D-01   0.36346D-02
CENTER NAVIGATION BASE           22426    -0.67905D-02   0.11363D-02  -0.51737D-01   0.28808D-02   0.19426D-01   0.36346D-02
CENTER NAVIGATION BASE           22426    -0.67905D-02   0.11363D-02  -0.51737D-01   0.28808D-02   0.19426D-01   0.36346D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.67905D-02   0.11363D-02  -0.51737D-01
CENTER NAVIGATION BASE           22426    -0.67905D-02   0.11363D-02  -0.51737D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.58501D+00  -0.45447D-02   0.22137D+01  -0.27747D-02   0.32978D+01   0.27947D-02

MODE# 18/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    294.26       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.42606D-01   0.10076D+00  -0.10957D+00   0.94243D-02  -0.19704D-01   0.16070D-02
RIGHT FLAP CENTER               160243    -0.18050D-01   0.10672D+00   0.22331D-01  -0.77398D-02  -0.27793D-01   0.82831D-03
LEFT RUDDER HINGE LINE POINT     81441     0.29165D-01   0.86794D-02   0.88685D-01  -0.91347D-02  -0.27433D-01  -0.29038D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.26951D-01   0.96136D-02  -0.88807D-01  -0.92581D-02   0.31854D-01  -0.26505D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.61037D-04   0.46459D-01  -0.40779D-02  -0.28857D-01   0.15569D-01   0.10271D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.61037D-04   0.46459D-01  -0.40779D-02  -0.28857D-01   0.15569D-01   0.10271D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02   0.29801D-01   0.16888D-01  -0.10609D+00
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02   0.29801D-01   0.16888D-01  -0.10609D+00
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02   0.29801D-01   0.16888D-01  -0.10609D+00

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.33041D-02   0.38593D-01   0.69851D-02  -0.21965D-01   0.16169D-01   0.30969D-02

MODE# 19/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    297.11       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.33864D-01   0.37649D-01   0.23169D+00  -0.48109D-01   0.14690D+00   0.60390D-02
RIGHT FLAP CENTER               160243    -0.34147D-01   0.11366D-01   0.24909D+00   0.57220D-01   0.13239D+00  -0.42243D-02
LEFT RUDDER HINGE LINE POINT     81441     0.55412D-02   0.44960D-02   0.38181D-01  -0.36252D-02  -0.22969D-01  -0.48880D-02
RIGHT RUDDER HINGE LINE POINT   181441    -0.84483D-02  -0.29883D-02  -0.23369D-01  -0.45596D-02   0.48563D-02  -0.12498D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34332D-04   0.20635D-01   0.20688D-01  -0.98870D-02  -0.10540D+00   0.11896D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34332D-04   0.20635D-01   0.20688D-01  -0.98870D-02  -0.10540D+00   0.11896D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01   0.86668D-02  -0.11380D+00  -0.11858D-01
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01   0.86668D-02  -0.11380D+00  -0.11858D-01
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01   0.86668D-02  -0.11380D+00  -0.11858D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298     0.22060D-01   0.21239D-01  -0.54345D-01  -0.57767D-02  -0.10976D+00  -0.49863D-02

MODE# 20/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    319.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.50196D-01  -0.40789D-01  -0.38652D+00   0.12459D-01  -0.44580D+00  -0.87010D-02
RIGHT FLAP CENTER               160243    -0.16634D-01   0.26835D-01  -0.50229D+00  -0.16486D-01  -0.36325D+00   0.16428D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.48973D-01   0.31855D-02   0.49316D-01   0.12474D-01  -0.63510D-01   0.55286D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.53112D-01   0.40017D-01   0.70281D-01  -0.66606D-02  -0.82421D-01  -0.31104D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.71547D-01   0.54607D-02   0.10848D+00   0.44828D-02  -0.43449D+00  -0.18257D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.71547D-01   0.54607D-02   0.10848D+00   0.44828D-02  -0.43449D+00  -0.18257D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298     0.20126D-01   0.87910D-02  -0.20232D+00   0.66520D-02  -0.45584D+00  -0.55342D-02

MODE# 21/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    331.28       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.87552D-01  -0.26330D-01   0.59045D-02  -0.39502D-01  -0.93514D-01   0.80926D-02
RIGHT FLAP CENTER               160243     0.75778D-01   0.13944D-01  -0.14616D+00   0.15661D-01  -0.12211D+00  -0.61042D-02
LEFT RUDDER HINGE LINE POINT     81441     0.11650D-01   0.10751D-01   0.66156D-01   0.10817D-01  -0.27441D-01   0.16791D-01
RIGHT RUDDER HINGE LINE POINT   181441     0.14078D-01  -0.51422D-02   0.44575D-01  -0.14211D-01  -0.13102D-01  -0.15636D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.40971D-01   0.13070D-01   0.91515D-01  -0.35541D-02  -0.35166D+00  -0.19143D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.40971D-01   0.13070D-01   0.91515D-01  -0.35541D-02  -0.35166D+00  -0.19143D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298     0.11505D+00   0.17776D-01  -0.15988D+00   0.94259D-03  -0.36860D+00  -0.10407D-01

MODE# 22/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    338.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.16520D+00   0.38899D-01   0.89818D-01  -0.13882D-01   0.10877D+00  -0.19167D-01
RIGHT FLAP CENTER               160243    -0.51139D-01  -0.27481D-02   0.53783D-01   0.29215D-02   0.45577D-01   0.46333D-02
LEFT RUDDER HINGE LINE POINT     81441    -0.31651D-01  -0.29139D-01  -0.26383D-01   0.27623D-02  -0.26053D-02   0.13570D-02
RIGHT RUDDER HINGE LINE POINT   181441    -0.34605D-01  -0.22298D-01  -0.30291D-01  -0.67459D-02   0.21949D-02  -0.30795D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.48754D-01  -0.21776D-01  -0.15673D-01  -0.20327D-02   0.33889D-01   0.38638D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.48754D-01  -0.21776D-01  -0.15673D-01  -0.20327D-02   0.33889D-01   0.38638D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02  -0.61511D-02   0.14494D+00   0.67076D-02
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02  -0.61511D-02   0.14494D+00   0.67076D-02
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02  -0.61511D-02   0.14494D+00   0.67076D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.55643D-01  -0.33750D-01   0.81217D-02  -0.11137D-01   0.34570D-01   0.23499D-01

MODE# 23/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    354.65       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.20176D+00   0.99058D-01  -0.27706D+00   0.56835D-01  -0.21717D+00  -0.50026D-01
RIGHT FLAP CENTER               160243    -0.13673D+00   0.65862D-01   0.32430D+00   0.96385D-01   0.30994D+00   0.42813D-02
LEFT RUDDER HINGE LINE POINT     81441    -0.29846D-01  -0.56684D-01  -0.17300D+00   0.14028D-01   0.64816D-01   0.67630D-02
RIGHT RUDDER HINGE LINE POINT   181441    -0.30522D-01  -0.43305D-01   0.14627D+00   0.34455D-01  -0.97934D-01   0.58261D-02
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.45761D-01  -0.16354D+00   0.15815D-02   0.45868D-01   0.78517D-01   0.19797D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.45761D-01  -0.16354D+00   0.15815D-02   0.45868D-01   0.78517D-01   0.19797D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01   0.46568D-01  -0.65990D+00   0.77592D-01
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01   0.46568D-01  -0.65990D+00   0.77592D-01
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01   0.46568D-01  -0.65990D+00   0.77592D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01
CENTER NAVIGATION BASE           22426     0.18392D+01  -0.83976D-01  -0.33151D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.62480D-01  -0.22775D+00   0.58115D-01  -0.19893D-01   0.83152D-01   0.14398D+00

MODE# 24/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    354.97       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.17881D+00   0.55608D-01  -0.26189D+00   0.72775D-01  -0.31685D+00   0.25117D-02
RIGHT FLAP CENTER               160243     0.16833D+00   0.13360D+00   0.26705D+00   0.64528D-01   0.17627D+00  -0.59934D-01
LEFT RUDDER HINGE LINE POINT     81441     0.39474D-01  -0.42542D-01  -0.12385D+00   0.35946D-01   0.93972D-01   0.28532D-02
RIGHT RUDDER HINGE LINE POINT   181441     0.37813D-01  -0.62310D-01   0.16908D+00   0.94209D-02  -0.56336D-01   0.28403D-02
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.60006D-01  -0.15826D+00   0.81637D-02   0.41502D-01  -0.11770D+00   0.19394D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.60006D-01  -0.15826D+00   0.81637D-02   0.41502D-01  -0.11770D+00   0.19394D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01   0.40425D-01   0.67617D+00   0.83151D-01
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01   0.40425D-01   0.67617D+00   0.83151D-01
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01   0.40425D-01   0.67617D+00   0.83151D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01
CENTER NAVIGATION BASE           22426    -0.18755D+01  -0.85260D-01   0.37401D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298     0.85014D-01  -0.22201D+00  -0.76451D-01  -0.22804D-01  -0.12438D+00   0.14187D+00

MODE# 25/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    359.54       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.41184D+00   0.54617D-01  -0.45819D-01  -0.21406D-01  -0.14563D+00  -0.66295D-01
RIGHT FLAP CENTER               160243    -0.29590D+00  -0.76520D-01  -0.93229D-01   0.28801D-01  -0.86398D-01   0.71183D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.92831D-01  -0.27625D-01  -0.19442D-02  -0.13571D-01  -0.66657D-01   0.22992D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.91628D-01   0.23680D-01   0.16386D-01   0.14687D-01  -0.73300D-01  -0.21622D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11383D+00  -0.58277D-02   0.90839D-01   0.25959D-02  -0.47449D-01   0.71110D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11383D+00  -0.58277D-02   0.90839D-01   0.25959D-02  -0.47449D-01   0.71110D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.10388D+00  -0.77899D-02   0.57285D-01   0.31174D-03  -0.49094D-01   0.47052D-02

MODE# 26/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    359.89       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.13928D+00   0.17836D-01  -0.95513D-01   0.93761D-02  -0.78782D-01  -0.26915D-01
RIGHT FLAP CENTER               160243    -0.10749D+00  -0.34901D-01  -0.89314D-01  -0.92139D-02  -0.48878D-01   0.30892D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.26797D-01  -0.38884D-02  -0.13625D-01  -0.78677D-02  -0.13237D-01   0.27622D-02
RIGHT RUDDER HINGE LINE POINT   181441    -0.25528D-01   0.85973D-02  -0.76898D-02   0.85163D-02  -0.15341D-01   0.99894D-03
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.40331D-01   0.13277D-02   0.18228D-02   0.10260D-02   0.59038D-01  -0.37225D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.40331D-01   0.13277D-02   0.18228D-02   0.10260D-02   0.59038D-01  -0.37225D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02

                              Node ID#     Modal Data at the Disturbance Point 
BODY FLAP CENTER POINT           70298    -0.52905D-01   0.27047D-02   0.44343D-01   0.18819D-02   0.62548D-01  -0.25411D-02
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
