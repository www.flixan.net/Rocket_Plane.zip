                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.14719D-01  -0.12009D-01   0.48469D-01   0.76648D-02   0.98291D-02   0.74454D-02                                                                                                
                                                                                                                                                                                                                            
MODE # 9/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    174.56       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.11413D-01  -0.17332D-01   0.28337D-01  -0.10856D-01  -0.13600D-01   0.33386D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.77301D-02  -0.42626D-02   0.86712D-01   0.29734D-01  -0.90546D-02  -0.10725D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.50040D+00  -0.14653D-01   0.13047D+00   0.25444D-01   0.26962D+00  -0.33121D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.56425D+00  -0.41249D-01   0.12007D+00  -0.80971D-02   0.34310D+00   0.32645D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.25698D-01  -0.23582D-01   0.21006D+00  -0.42739D-02   0.25229D+00   0.17062D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.25698D-01  -0.23582D-01   0.21006D+00  -0.42739D-02   0.25229D+00   0.17062D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01   0.38503D-03  -0.66226D-02   0.30360D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01   0.38503D-03  -0.66226D-02   0.30360D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01   0.38503D-03  -0.66226D-02   0.30360D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.55027D-01  -0.58177D-01   0.14789D+00   0.29490D-01   0.40124D-01   0.31730D-01                                                                                                
                                                                                                                                                                                                                            
MODE #10/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    178.24       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.40545D-01  -0.62979D-01   0.29798D+00  -0.88866D-01   0.39205D-01   0.14108D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.39180D-01  -0.62358D-01  -0.29484D+00  -0.86288D-01  -0.40017D-01   0.14244D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.42437D+00   0.52190D-01   0.29733D-01  -0.14607D-01   0.27123D+00  -0.19752D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.40314D+00   0.50568D-01  -0.26856D-01  -0.15694D-01  -0.25784D+00  -0.18620D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.14661D-02   0.61585D-01   0.37109D-02  -0.13072D-01   0.52848D-02  -0.11900D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.14661D-02   0.61585D-01   0.37109D-02  -0.13072D-01   0.52848D-02  -0.11900D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.90251D-03  -0.60174D-01   0.91910D-02   0.32362D-01   0.55886D-03   0.54519D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.90251D-03  -0.60174D-01   0.91910D-02   0.32362D-01   0.55886D-03   0.54519D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.90251D-03  -0.60174D-01   0.91910D-02   0.32362D-01   0.55886D-03   0.54519D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.90251D-03  -0.60174D-01   0.91910D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.90251D-03  -0.60174D-01   0.91910D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.51039D-01   0.76432D-01  -0.15142D-01  -0.10647D-01  -0.13852D-01  -0.33333D-01                                                                                                
                                                                                                                                                                                                                            
MODE #11/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    187.74       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.56989D-01  -0.30457D-01  -0.15421D+00   0.66675D-01   0.17176D-02  -0.60231D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.39516D-01  -0.48706D-01  -0.46445D-01  -0.24517D-01   0.12739D-02   0.14743D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.51235D+00  -0.10033D+00   0.37524D-01   0.68871D-03  -0.41041D+00   0.22164D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.98215D-01  -0.48668D-01  -0.17903D-01   0.28621D-01   0.10793D+00   0.48358D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.37672D-01  -0.11493D-01  -0.33126D-01  -0.11908D-01  -0.10259D+00  -0.20928D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.37672D-01  -0.11493D-01  -0.33126D-01  -0.11908D-01  -0.10259D+00  -0.20928D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00   0.88085D-02   0.15483D-01   0.46816D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00   0.88085D-02   0.15483D-01   0.46816D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00   0.88085D-02   0.15483D-01   0.46816D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.38351D-01  -0.85368D-01  -0.41343D-01  -0.15485D-01   0.34578D-03   0.13860D-01                                                                                                
                                                                                                                                                                                                                            
MODE #12/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    191.66       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.10524D-01   0.16953D-01  -0.80601D-01   0.37195D-01  -0.67365D-02   0.64142D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.10202D+00  -0.53278D-03  -0.11634D+00  -0.56932D-01   0.29217D-02   0.12856D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.25575D+00  -0.13894D-01  -0.11109D-01  -0.14241D-01   0.20337D+00  -0.17917D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.48296D+00   0.40397D-01   0.46021D-01   0.17247D-01  -0.37775D+00  -0.23326D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.34377D-01  -0.71635D-01  -0.21858D-01   0.58121D-02  -0.77920D-01   0.92247D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.34377D-01  -0.71635D-01  -0.21858D-01   0.58121D-02  -0.77920D-01   0.92247D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00  -0.73553D-02   0.15726D-01   0.14277D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00  -0.73553D-02   0.15726D-01   0.14277D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00  -0.73553D-02   0.15726D-01   0.14277D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.41471D-01   0.16469D-01   0.15344D-01   0.24891D-03  -0.29466D-01  -0.14717D-02                                                                                                
                                                                                                                                                                                                                            
MODE #13/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    197.96       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.40493D-01   0.20132D-01  -0.96192D-01   0.64493D-01  -0.37609D-02   0.29217D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.65020D-01   0.64252D-02  -0.10131D+00  -0.64878D-01  -0.61826D-02  -0.70801D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.35918D-01   0.28944D-01   0.53188D-01   0.14604D-01   0.45952D-01  -0.11836D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.10800D+00  -0.60591D-02   0.39619D-01  -0.20045D-01   0.99203D-01   0.57194D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.18941D-01   0.23957D-01   0.56693D-01  -0.95477D-03   0.19370D+00  -0.15168D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.18941D-01   0.23957D-01   0.56693D-01  -0.95477D-03   0.19370D+00  -0.15168D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00   0.39075D-02  -0.76919D-02  -0.78351D-02                                                                                                
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00   0.39075D-02  -0.76919D-02  -0.78351D-02                                                                                                
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00   0.39075D-02  -0.76919D-02  -0.78351D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.14083D-01   0.74298D-02   0.56530D-01   0.33000D-02  -0.11015D-01  -0.42803D-02                                                                                                
                                                                                                                                                                                                                            
MODE #14/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    204.74       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.82904D-01   0.19357D+00   0.69557D-01  -0.15632D-01   0.29545D-01  -0.10975D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.52241D-01   0.19107D+00  -0.69201D-01  -0.16842D-01  -0.37132D-01  -0.10191D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.10391D+00   0.61041D-01   0.66399D-01  -0.36144D-01  -0.95861D-01   0.32148D-02                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.20580D+00   0.89700D-01  -0.14047D+00  -0.51936D-02   0.18234D+00   0.91732D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.15959D-01   0.19006D+00  -0.67413D-01  -0.27661D-01  -0.11643D+00  -0.22682D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.15959D-01   0.19006D+00  -0.67413D-01  -0.27661D-01  -0.11643D+00  -0.22682D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01   0.53021D-01   0.62357D-02  -0.10971D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01   0.53021D-01   0.62357D-02  -0.10971D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01   0.53021D-01   0.62357D-02  -0.10971D+00                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.33915D-01  -0.13440D+00  -0.22280D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.17836D-01   0.58687D-01  -0.10934D+00  -0.26831D-01  -0.54179D-02   0.83984D-02                                                                                                
                                                                                                                                                                                                                            
MODE #15/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    212.28       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.83480D-01   0.81759D-01  -0.15687D+00   0.54831D-01   0.95507D-02   0.56544D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.89734D-01   0.83681D-01   0.55333D-01   0.28769D-01   0.96045D-02   0.15385D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.10642D+00  -0.12391D+00   0.27646D+00   0.54135D-01  -0.18107D+00  -0.79518D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.25123D+00  -0.16154D+00   0.16471D-02  -0.11191D-01  -0.14295D+00  -0.30636D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37463D-01  -0.72375D-01   0.22229D+00  -0.58679D-01   0.37922D+00   0.21313D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37463D-01  -0.72375D-01   0.22229D+00  -0.58679D-01   0.37922D+00   0.21313D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01   0.84312D-01   0.14697D-01  -0.29894D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01   0.84312D-01   0.14697D-01  -0.29894D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01   0.84312D-01   0.14697D-01  -0.29894D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.73854D-01  -0.20060D+00   0.65565D-01  -0.66043D-01   0.11262D-01   0.10880D-01                                                                                                
                                                                                                                                                                                                                            
MODE #16/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    213.34       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.82634D-01  -0.14071D-01  -0.15927D-01   0.12720D-02   0.32561D-01  -0.15804D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.29162D-01  -0.15080D-01  -0.20252D+00  -0.70445D-01   0.14175D-01   0.35392D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.22007D+00   0.11137D+00   0.55177D-01   0.71670D-02  -0.13803D+00   0.20623D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.10907D+00   0.94893D-01   0.20621D+00  -0.39364D-01  -0.14707D+00   0.37735D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37273D-01   0.66994D-01   0.19565D+00   0.33901D-01   0.33495D+00  -0.12356D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37273D-01   0.66994D-01   0.19565D+00   0.33901D-01   0.33495D+00  -0.12356D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01  -0.49634D-01   0.36590D-01  -0.50653D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01  -0.49634D-01   0.36590D-01  -0.50653D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01  -0.49634D-01   0.36590D-01  -0.50653D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.48520D-02   0.13745D+00   0.22952D+00   0.31261D-01   0.25466D-02  -0.13927D-01                                                                                                
                                                                                                                                                                                                                            
MODE #17/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    217.34       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.40299D-02   0.19201D-02   0.53943D-01  -0.19972D-01  -0.31820D-01  -0.15372D-03                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.45169D-01  -0.89966D-03  -0.33944D-01  -0.12068D-01  -0.41449D-01  -0.50529D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.24933D+00   0.64744D-01   0.17729D+00   0.34012D-01  -0.22368D+00   0.19362D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.20682D+00   0.27358D-01   0.23834D+00  -0.47408D-01  -0.22941D+00  -0.95107D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.31758D-01   0.31171D-01   0.32350D+00   0.13782D-01   0.57805D+00  -0.50773D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.31758D-01   0.31171D-01   0.32350D+00   0.13782D-01   0.57805D+00  -0.50773D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01  -0.21513D-01  -0.19543D-01  -0.97179D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01  -0.21513D-01  -0.19543D-01  -0.97179D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01  -0.21513D-01  -0.19543D-01  -0.97179D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.56718D-01   0.59443D-01   0.28981D+00   0.86756D-02   0.92774D-02  -0.99327D-02                                                                                                
                                                                                                                                                                                                                            
MODE #18/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    231.42       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.25081D+00  -0.36049D-01  -0.18362D+00   0.57122D-01  -0.73392D-01  -0.51381D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.23370D+00  -0.38874D-01   0.10456D+00   0.33550D-01   0.50047D-01  -0.45578D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.10092D+00   0.18066D+00   0.38837D-01  -0.31389D-01  -0.76546D-01   0.13518D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.79330D-01   0.18455D+00  -0.11537D-01  -0.31885D-01   0.59092D-01   0.13303D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.14532D-02   0.27341D+00   0.15647D-01   0.10699D-01   0.43523D-01  -0.34131D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.14532D-02   0.27341D+00   0.15647D-01   0.10699D-01   0.43523D-01  -0.34131D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01   0.41521D-01   0.47452D-02   0.13802D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01   0.41521D-01   0.47452D-02   0.13802D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01   0.41521D-01   0.47452D-02   0.13802D+00                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.44622D-01   0.20998D+00   0.25057D-01   0.22916D-02  -0.36726D-03  -0.20004D-01                                                                                                
                                                                                                                                                                                                                            
MODE #19/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    240.46       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.30858D-01  -0.30933D-01   0.41221D+00  -0.14163D+00   0.14705D+00   0.23637D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.74871D-01   0.21121D-01   0.38835D+00   0.13520D+00   0.13456D+00  -0.30014D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.79444D-01   0.24622D-01   0.65734D-01   0.64805D-02  -0.12575D+00   0.83713D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.59273D-01   0.19656D-01   0.54761D-01  -0.15535D-01  -0.10329D+00  -0.52758D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34466D-01   0.36712D-01   0.17774D+00   0.43965D-03   0.38563D+00  -0.48072D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34466D-01   0.36712D-01   0.17774D+00   0.43965D-03   0.38563D+00  -0.48072D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01                                                                                                
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.91984D-01   0.28090D-01   0.10084D+00  -0.50378D-02   0.46074D-01  -0.19893D-02                                                                                                
                                                                                                                                                                                                                            
MODE #20/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    246.71       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.51927D-01  -0.17792D-01   0.14587D+00  -0.39046D-01   0.95368D-01   0.18220D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.58506D-01  -0.22140D-01  -0.20514D+00  -0.61604D-01  -0.11655D+00   0.22222D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.19842D-01   0.14028D+00  -0.58451D-01  -0.11268D-01   0.32263D-01   0.88247D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.20991D-01   0.14017D+00   0.61169D-01  -0.10846D-01  -0.22772D-01   0.95899D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.54031D-03   0.99347D-01  -0.43729D-02   0.31893D-01  -0.18734D-02  -0.14781D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.54031D-03   0.99347D-01  -0.43729D-02   0.31893D-01  -0.18734D-02  -0.14781D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.11205D-01  -0.21164D-01  -0.13077D-01   0.16063D-02   0.67267D-02   0.41720D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.11205D-01  -0.21164D-01  -0.13077D-01   0.16063D-02   0.67267D-02   0.41720D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.11205D-01  -0.21164D-01  -0.13077D-01   0.16063D-02   0.67267D-02   0.41720D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.11205D-01  -0.21164D-01  -0.13077D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.11205D-01  -0.21164D-01  -0.13077D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.22062D-01   0.16233D+00   0.56642D-01   0.27972D-01  -0.58388D-02  -0.94261D-02                                                                                                
                                                                                                                                                                                                                            
MODE #21/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    267.87       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.26532D-01   0.41141D-01   0.17030D+00  -0.53483D-01   0.10259D+00   0.12867D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.24021D-01   0.40607D-01  -0.20159D+00  -0.64204D-01  -0.11641D+00   0.13772D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.43402D-01  -0.43287D-01   0.27732D+00  -0.35534D-01  -0.19009D+00  -0.62367D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.45157D-01  -0.42750D-01  -0.27994D+00  -0.35296D-01   0.19641D+00  -0.58815D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.29894D-02   0.23051D+00  -0.96089D-02  -0.95400D-01  -0.56419D-01  -0.15582D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.29894D-02   0.23051D+00  -0.96089D-02  -0.95400D-01  -0.56419D-01  -0.15582D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.22604D-02  -0.13809D+00  -0.14315D-02   0.87610D-01  -0.28352D-02   0.17780D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.22604D-02  -0.13809D+00  -0.14315D-02   0.87610D-01  -0.28352D-02   0.17780D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.22604D-02  -0.13809D+00  -0.14315D-02   0.87610D-01  -0.28352D-02   0.17780D+00                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.22604D-02  -0.13809D+00  -0.14315D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.22604D-02  -0.13809D+00  -0.14315D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538     0.59844D-01  -0.58237D-01  -0.18648D+00  -0.84962D-01   0.16770D-03  -0.21654D-01                                                                                                
                                                                                                                                                                                                                            
MODE #22/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    294.26       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.42606D-01   0.10076D+00  -0.10957D+00   0.94243D-02  -0.19704D-01   0.16070D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.19555D-01   0.10740D+00   0.23563D-01  -0.89373D-02  -0.28113D-01   0.15012D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.29165D-01   0.86794D-02   0.88685D-01  -0.91347D-02  -0.27433D-01  -0.29038D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.26951D-01   0.96136D-02  -0.88807D-01  -0.92581D-02   0.31854D-01  -0.26505D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.61037D-04   0.46459D-01  -0.40779D-02  -0.28857D-01   0.15569D-01   0.10271D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.61037D-04   0.46459D-01  -0.40779D-02  -0.28857D-01   0.15569D-01   0.10271D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02   0.29801D-01   0.16888D-01  -0.10609D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02   0.29801D-01   0.16888D-01  -0.10609D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02   0.29801D-01   0.16888D-01  -0.10609D+00                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.37409D+00   0.15958D-01  -0.95831D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.79563D-02  -0.14062D-01  -0.57357D-01  -0.27066D-01  -0.46752D-02   0.95749D-02                                                                                                
                                                                                                                                                                                                                            
MODE #23/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    317.06       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.11683D+00   0.51829D-01  -0.23021D+00   0.75142D-01  -0.12533D+00   0.69237D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.11013D+00   0.43326D-01   0.34229D+00   0.86069D-01   0.23874D+00   0.68409D-03                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.23572D-01   0.43963D-01  -0.69840D-01   0.15941D-01   0.69693D-01   0.16250D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.98144D-02   0.37857D-01   0.67110D-01   0.16847D-01  -0.57592D-01   0.24501D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10415D-01  -0.59507D-01  -0.38869D-02   0.25894D-01   0.16844D-01   0.12758D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10415D-01  -0.59507D-01  -0.38869D-02   0.25894D-01   0.16844D-01   0.12758D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02   0.49641D-01   0.67975D-01   0.16358D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02   0.49641D-01   0.67975D-01   0.16358D+00                                                                                                
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02   0.49641D-01   0.67975D-01   0.16358D+00                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.30818D-01   0.25622D-01   0.41221D-01   0.17267D-01   0.29466D-02   0.16911D-01                                                                                                
                                                                                                                                                                                                                            
MODE #24/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    319.80       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.50196D-01  -0.40789D-01  -0.38652D+00   0.12459D-01  -0.44580D+00  -0.87010D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.38709D-01   0.40601D-01  -0.28800D+00   0.10989D-01  -0.37014D+00   0.19376D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441    -0.48973D-01   0.31855D-02   0.49316D-01   0.12474D-01  -0.63510D-01   0.55286D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.53112D-01   0.40017D-01   0.70281D-01  -0.66606D-02  -0.82421D-01  -0.31104D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.71547D-01   0.54607D-02   0.10848D+00   0.44828D-02  -0.43449D+00  -0.18257D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.71547D-01   0.54607D-02   0.10848D+00   0.44828D-02  -0.43449D+00  -0.18257D-03                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01                                                                                                
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.12443D+00   0.12328D-01   0.10169D+00   0.53511D-02   0.74090D-02   0.21169D-01                                                                                                
                                                                                                                                                                                                                            
MODE #25/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    331.28       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008     0.87552D-01  -0.26330D-01   0.59045D-02  -0.39502D-01  -0.93514D-01   0.80926D-02                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.87060D-01   0.12492D-01  -0.40659D-01   0.24659D-01  -0.12282D+00  -0.50523D-02                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.11650D-01   0.10751D-01   0.66156D-01   0.10817D-01  -0.27441D-01   0.16791D-01                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441     0.14078D-01  -0.51422D-02   0.44575D-01  -0.14211D-01  -0.13102D-01  -0.15636D-01                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.40971D-01   0.13070D-01   0.91515D-01  -0.35541D-02  -0.35166D+00  -0.19143D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.40971D-01   0.13070D-01   0.91515D-01  -0.35541D-02  -0.35166D+00  -0.19143D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02                                                                                                
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01                                                                                                                                          
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.13403D-01   0.37829D-03   0.69875D-01   0.19023D-02   0.12148D-01   0.42055D-03                                                                                                
                                                                                                                                                                                                                            
MODE #26/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    342.40       0.50000E-02    12.000                                                                                                                  
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z                                                                                               
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges)                                                                                                                                   
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.61626D+00   0.22185D+00   0.30187D+00  -0.76694D-01   0.30956D+00  -0.97042D-01                                                                                                
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.60445D+00   0.22380D+00  -0.36470D+00  -0.79697D-01  -0.38975D+00  -0.90796D-01                                                                                                
LEFT RUDDER HINGE LINE POINT     81441     0.18784D-01  -0.29861D+00   0.19793D-01  -0.17128D-01  -0.20692D-01  -0.16500D+00                                                                                                
RIGHT RUDDER HINGE LINE POINT   181441    -0.24578D-01  -0.29787D+00  -0.93551D-02  -0.18152D-01   0.12306D-01  -0.16901D+00                                                                                                
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.24281D-02  -0.27693D+00   0.92157D-02  -0.22170D-01  -0.17995D-01   0.48780D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...                                                                                                                                         
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.24281D-02  -0.27693D+00   0.92157D-02  -0.22170D-01  -0.17995D-01   0.48780D-01                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  3 Gyros ...                                                                                                                                                   
CENTER NAVIGATION BASE           22426     0.26694D+00  -0.72780D-01  -0.70971D-02  -0.76653D-01  -0.83742D-01   0.10138D+00                                                                                                
CENTER NAVIGATION BASE           22426     0.26694D+00  -0.72780D-01  -0.70971D-02  -0.76653D-01  -0.83742D-01   0.10138D+00                                                                                                
CENTER NAVIGATION BASE           22426     0.26694D+00  -0.72780D-01  -0.70971D-02  -0.76653D-01  -0.83742D-01   0.10138D+00                                                                                                
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...                                                                                                                            
CENTER NAVIGATION BASE           22426     0.26694D+00  -0.72780D-01  -0.70971D-02                                                                                                                                          
CENTER NAVIGATION BASE           22426     0.26694D+00  -0.72780D-01  -0.70971D-02                                                                                                                                          
                                                                                                                                                                                                                            
                              Node ID#     Modal Data at the Disturbance Point                                                                                                                                              
Thruster RUa, +Z                113538    -0.90870D-01  -0.30197D+00  -0.87608D-02  -0.46310D-02  -0.84820D-02   0.41018D-01                                                                                                
