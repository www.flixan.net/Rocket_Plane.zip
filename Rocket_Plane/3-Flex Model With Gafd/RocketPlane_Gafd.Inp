BATCH MODE INSTRUCTIONS ...............                                                             
Batch for the Flexible Rocket Plane with GAFD                               
! This batch creates a flexible model for the rocket plane including 30 modes from all directions.                                                                                                                          
! In addition to the modal data this vehicle also reads GAFD data from file: RocketPlane.Gaf                                                                                                                       
! It creates also electro-mechanical actuator models for the flaps, rudders and body-flap aerosurfaces
! It preserves the previously calculated effectors mixing logic for the five aero-surfaces and 
! the engine throttle control.  
!                                                                                                                                                                               
Retain Matrix    : Coupled axes Mixing Matrix for Rocket-Plane, K4axmix
Flight Vehicle   : Rocket Plane at Mach=0.85, Q=150, Aero-Elastic Model with GAFD (Batch)                                                                                                                                                             
Actuator Model   : Electro-Mechanical Flap Type-B Actuator                                                                                                                                                 
Actuator Model   : Electro-Mechanical Rudder Type-B Actuator                                                                                                                                                 
Actuator Model   : Electro-Mechanical Body-Flap Type-B Actuator                                                                                                                                                 
!
!                  Save Systems and Matrices for Matlab
To Matlab Format : Rocket Plane at Mach=0.85, Q=150, Aero-Elastic Model with GAFD (Batch)                                                                       
To Matlab Format : Electro-Mechanical Flap Type-B Actuator                                                                                                                                                  
To Matlab Format : Electro-Mechanical Rudder Type-B Actuator                                                                                                                                                   
To Matlab Format : Electro-Mechanical Body-Flap Type-B Actuator                                                                                                                                                  
To Matlab Format : Coupled axes Mixing Matrix for Rocket-Plane, K4axmix
------------------------------------------------------------------------------------------------------------------------                                                                                                    
FLIGHT VEHICLE INPUT DATA ......
Rocket Plane at Mach=0.85, Q=150, Aero-Elastic Model with GAFD
! This Vehicle is a Rocket Plane that has five control surfaces: 2 flaps, 2 rudders, and 
! a body-flap. It also has a fixed throttling engine. 
! The "Include GAFD" is On, and also "tail-wags-dog" option on the aerosurfaces is turned on.
! This version does not run in Batch mode because it does not have the Selected GAFD frequency
! numbers and the selected surface numbers at the bottom of the set. 
! It can only run interactively.
!
Body Axes Output, Attitude=Euler Angles, Include GAFD, No Turn Coordination  

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  198.32       32.17        0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  1098.0       10933.       11290.       0.0000       123.75       0.0000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -15.167       0.0000       0.467 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.85000      822.80       150.13       45880.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -0.81        -1.14         0.0000      -32.15    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.0          0.0          1.76         0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.16079      2.0000       0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  79.0         6.1          15.0    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -14.792       0.0000      0.54000       0.0000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.143,  -0.0039,   0.0004, 0.0,    0.0,    -0.244,  0.0    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.0245,   1.77,   0.0,    0.00838, 0.0,    0.0
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.14,   -0.073,   -9.93,   0.0,    0.0,     0.0,    0.00093
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.00212,  0.0,   -0.393,  0.427,   0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.0838, -0.015,    0.0,    0.0,   -12.83,   0.0004, 0.0    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,     0.001,    0.0,    0.184, -1.49,    0.0

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  5   WITH TWD

Control Surface No:  1                                                                     Left Flap                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0           30.000     -30.000       +2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.4          0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7       -2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03 -0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.11893E-02 -0.26625E-02  0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  2                                                                     Right Flap                                                                                                                       
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0           30.000     -30.000       -2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.4          0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7        2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03  0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.11893E-02 -0.26625E-02 -0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  3                                                                     Left Rudder                                                                                                                      
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000        48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        4.0          0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019        0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333    -3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03  0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.17964E-02 -0.98720E-02 -0.35668E-02   0.0000       0.0000       0.0000                                                        
Control Surface No:  4                                                                     Right Rudder                                                                                                                     
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000       -48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        4.0          0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019       -0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333     3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03 -0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.17964E-02 -0.98720E-02  0.35668E-02   0.0000       0.0000       0.0000                                                        
Control Surface No:  5                                                                     Body Flap                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -10.0         40.000      -40.000       0.0000       0.0000                                                                     
Surface Mass, Inertia about Hinge, Moment Arm (hinge to surface CG), Surface Chord & Area:   1.8          2.2         0.6           1.6670       5.7430                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.1e-03       0.0000     -0.10E-03      0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.8         0.0000      0.80000                                                                                               
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.83830E-05   0.0000     -0.59235E-03   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.0000     -0.15765E-02   0.0000       0.0000       0.0000       0.0000                                                        

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  1  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Engine Throtl    Throttling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  2000.0        4000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  -1.3          0.0         0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   2.00         65.0        0.8    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -26.5         0.0         0.0    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No 1 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Roll Rate               -8.8, 0.0, -0.19
Gyro No 2 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Pitch Rate              -8.8, 0.0, -0.19
Gyro No 3 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Yaw Rate                -8.8, 0.0, -0.19

Number of Accelerometers, (x,y,z)                                                        :  2
Acceleromet No 1 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  Y-axis Acceleration     -8.8, 0.0, -0.19
Acceleromet No 2 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  Z-axis Acceleration     -8.8, 0.0, -0.19

Number of Bending Modes                                                                  : 30
Rocket Plane at Mach=0.85, Q=150, Flex Model, (30 Mixed Modes)                                             
--------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Rocket Plane at Mach=0.85, Q=150, Aero-Elastic Model with GAFD (Batch)
! This Vehicle is a Rocket Plane that has five control surfaces: 2 flaps, 2 rudders, and 
! a body-flap. It also has a fixed throttling engine. 
! The "Include GAFD" is on, and also "tail-wags-dog" option on the aerosurfaces is turned on.
! This version can run in Batch mode because it includes the selected GAFD frequencies and
! the corresponding aerosurface numbers at the bottom of the set.
!
Body Axes Output, Attitude=Euler Angles,Include GAFD, No Turn Coordination  

Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  198.32       32.17        0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  1098.0       10933.       11290.       0.0000       123.75       0.0000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -15.167       0.0000       0.467 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.85000      822.80       150.13       45880.    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -0.81        -1.14         0.0000      -32.15    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.0          0.0          1.76         0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.16079      2.0000       0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  79.0         6.1          15.0    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -14.792       0.0000      0.54000       0.0000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.143,  -0.0039,   0.0004, 0.0,    0.0,    -0.244,  0.0    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    -0.0245,   1.77,   0.0,    0.00838, 0.0,    0.0
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.14,   -0.073,   -9.93,   0.0,    0.0,     0.0,    0.00093
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    -0.00212,  0.0,   -0.393,  0.427,   0.0
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.0838, -0.015,    0.0,    0.0,   -12.83,   0.0004, 0.0    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,     0.001,    0.0,    0.184, -1.49,    0.0

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  5   WITH TWD

Control Surface No:  1                                                                     Left Flap                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0           30.000     -30.000       +2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.4          0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047      -0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7       -2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03 -0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.11893E-02 -0.26625E-02  0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  2                                                                     Right Flap                                                                                                                       
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0           30.000     -30.000       -2.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  1.185        0.4          0.283         1.2070       5.5530                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.0047       0.00055     -0.0097        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -18.7        2.64         2.0733                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.45432E-03  0.24668E-02 -0.60478E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.11893E-02 -0.26625E-02 -0.81515E-03   0.0000       0.0000       0.0000                                                        
Control Surface No:  3                                                                     Left Rudder                                                                                                                      
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000        48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        4.0          0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019        0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333    -3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03  0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.17964E-02 -0.98720E-02 -0.35668E-02   0.0000       0.0000       0.0000                                                        
Control Surface No:  4                                                                     Right Rudder                                                                                                                     
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -1.2         30.000      -30.000       -48.000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   2.19        4.0          0.833         2.2830       10.382                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.019       -0.0229      -0.0236        0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.3333     3.395       -1.6242                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.46197E-03 -0.47413E-02 -0.51664E-02   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}: -0.17964E-02 -0.98720E-02  0.35668E-02   0.0000       0.0000       0.0000                                                        
Control Surface No:  5                                                                     Body Flap                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  -10.0         40.000      -40.000       0.0000       0.0000                                                                     
Surface Mass, Inertia about Hinge, Moment Arm (hinge to surface CG), Surface Chord & Area:   1.8          2.2         0.6           1.6670       5.7430                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.1e-03       0.0000     -0.10E-03      0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -25.8         0.0000      0.80000                                                                                               
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.83830E-05   0.0000     -0.59235E-03   0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.0000     -0.15765E-02   0.0000       0.0000       0.0000       0.0000                                                        

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  1  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Engine Throtl    Throttling   
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  2000.0        4000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  -1.3          0.0         0.0           0.0    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   2.00         65.0        0.8    
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  -26.5         0.0         0.0    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No 1 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Roll Rate               -8.8, 0.0, -0.19
Gyro No 2 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Pitch Rate              -8.8, 0.0, -0.19
Gyro No 3 Axis:(Pitch,Yaw,Roll), (Attitude or Rate), Location in Vehicle Axes  (feet)    :  Yaw Rate                -8.8, 0.0, -0.19

Number of Accelerometers, (x,y,z)                                                        :  2
Acceleromet No 1 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  Y-axis Acceleration     -8.8, 0.0, -0.19
Acceleromet No 2 Axis:(X,Y,Z), (Acceleration,Flex_Posit,Flex_Veloc,Flex_Accel), Locat(ft):  Z-axis Acceleration     -8.8, 0.0, -0.19

Number of Bending Modes                                                                  : 30
Rocket Plane at Mach=0.85, Q=150, Flex Model, (30 Mixed Modes)                                             
Selected GAFD Mode Numbers from GAFD File                                                :  1  2  3  4  5  6  7  8  9 10 11 12 13 14 15 16 17 18 19 20 22 24 26 27 28 30 31 32 33 34  
Selected GAFD Surface Numbers from GAFD File                                             :  1  2  3  4  5  
--------------------------------------------------------------------------------------------------------------------------------------
            3 ELECTRO-MECHANICAL ACTUATOR MODELS (2-Flaps, 2-Rudders and Body-Flap)
--------------------------------------------------------------------------------------------------------------------------------------                                                                                      
ACTUATOR INPUT DATA ............ ELECTROMECHANICAL TYPE B 
Electro-Mechanical Flap Type-B Actuator
! This EMA system has a full PID controller with a second order compensator
!
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      2, 1.2,2000.0, 0.6,250.0
Kpl    Position Error Loop Gain                 (Volt/ft)    60.0
Krf    Rate Feedback Gain                   (Volt/ft/sec)    0.00045
Ki     Position Error Integral Gain         (Volt/ft-sec)    10.0
Wm     Servo Motor Bandwidth,                 (rad/sec)      1200.0
Kv     Servo Motor Torque Gain               (ft-lb/volt)    100.0
Jm     Motor Rotor Moment of Inertia         (ft-lb-sec^2)   2.0e-5
Ngr    Gear Ratio (Motor Turns/ Screw Turns)        ( - )    10.25
Nscr   Screw Ratio (Piston Extension/Screw Turns) (ft/rad)   0.0026
Kgs    Motor Gear Stiffness                    (ft-lb/rad)   350.0
Kmfr   Motor/ Gear Friction                (ft-lb/rad/sec)   0.03
Kdmp   Shaft Damping Friction              (ft-lb/rad/sec)   0.004
Keff   Gear Effectiveness Coefficient               ( - )    0.8
Ja     Gear plus Screw Inertia               (ft-lb-sec^2)   4.6e-4
Kact   Actuator Stiffness (Piston+Electric).... (lb/ft)      2.0e+6
Klod   Load Stiffness,(Con. Surface or Nozzle)  (lb/ft)      0.5e+6
Kbck   Vehicle Backup Structure Stiffness ..... (lb/ft)      0.5e+6
R      Moment Arm of Actuator Shaft from Gimbal..  (feet)    0.4
Je     Load Inertia about the Gimbal ....... (ft-lb-sec^2)   0.4 
Be     Aero-Surface Bearing Viscous Damping   (ft-lb-sec)    30.0
Kg     Aero-Surface Bearing Spring Constant   (ft-lb/rad)    0.0    
------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ ELECTROMECHANICAL TYPE B 
Electro-Mechanical Rudder Type-B Actuator
! This EMA actuator Uses an Extendable Shaft to Drive a Load.
! The end of the rod is attached to a lever arm that rotates the Aero-Surface.
! Input-1 is the Deflection command in (rad)
! Input-2 is the Load-Torque in (foot pounds)
! The Outputs are in radians
!
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      1, 0.0, 0.01
Kpl    Position Error Loop Gain                 (Volt/ft)    480.0
Krf    Rate Feedback Gain                   (Volt/in/sec)    0.004
Ki     Position Error Integral Gain         (Volt/ft-sec)    1.2
Wm     Servo Motor Bandwidth,                 (rad/sec)      2000.0
Kv     Servo Motor Torque Gain               (ft-lb/volt)    300.0
Jm     Motor Rotor Moment of Inertia         (ft-lb-sec^2)   0.8e-4
Ngr    Gear Ratio (Motor Turns/ Screw Turns)        ( - )    17.0
Nscr   Screw Ratio (Piston Extension/Screw Turns) (ft/rad)   0.0027
Kgs    Motor Gear Stiffness                    (ft-lb/rad)   700.0
Kmfr   Motor/ Gear Friction                (ft-lb/rad/sec)   0.005
Kdmp   Shaft Damping Friction              (ft-lb/rad/sec)   0.002
Keff   Gear Effectiveness Coefficient               ( - )    0.85
Ja     Gear plus Screw Moment of Inertia ... (ft-lb-sec^2)   2.5e-4
Kact   Actuator Stiffness (Piston+Electric).... (lb/ft)      0.32e+7
Klod   Load Stiffness,(Con. Surface or Nozzle)  (lb/ft)      0.34e+7
Kbck   Vehicle Backup Structure Stiffness ..... (lb/ft)      0.42e+7
R      Moment Arm of Actuator Rod from Gimbal..    (ft)      0.3
Je     Load Inertia about the Gimbal ....... (ft-lb-sec^2)   4.0 
Be     Nozzle Bearing Viscous Damping ....... (in-lb-sec)    80.0
Kg     Gimbal Bearing Spring Constant          (in-lb/rad)   0.0000    
---------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ ELECTROMECHANICAL TYPE B 
Electro-Mechanical Body-Flap Type-B Actuator
! This EMA actuator Uses an Extendable Shaft to Drive a Load.
! The end of the rod is attached to a lever arm that rotates the Aero-Surface.
! Input-1 is the Deflection command in (rad)
! Input-2 is the Load-Torque in (foot pounds)
! The Outputs are in radians
!
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      1, 0.0, 0.0125
Kpl    Position Error Loop Gain                 (Volt/ft)    140.0
Krf    Rate Feedback Gain                   (Volt/in/sec)    0.0005
Ki     Position Error Integral Gain         (Volt/ft-sec)    5.0
Wm     Servo Motor Bandwidth,                 (rad/sec)      1800.0
Kv     Servo Motor Torque Gain               (ft-lb/volt)    260.0
Jm     Motor Rotor Moment of Inertia         (ft-lb-sec^2)   5.0e-5
Ngr    Gear Ratio (Motor Turns/ Screw Turns)        ( - )    10.2
Nscr   Screw Ratio (Piston Extension/Screw Turns) (ft/rad)   0.0026
Kgs    Motor Gear Stiffness                    (ft-lb/rad)   400.0
Kmfr   Motor/ Gear Friction                (ft-lb/rad/sec)   0.03
Kdmp   Shaft Damping Friction              (ft-lb/rad/sec)   0.001
Keff   Gear Effectiveness Coefficient               ( - )    0.85
Ja     Gear plus Screw Moment of Inertia ... (ft-lb-sec^2)   2.0e-4
Kact   Actuator Stiffness (Piston+Electric).... (lb/ft)      2.4e+7
Klod   Load Stiffness,(Con. Surface or Nozzle)  (lb/ft)      0.36e+7
Kbck   Vehicle Backup Structure Stiffness ..... (lb/ft)      0.36e+7
R      Moment Arm of Actuator Rod from Gimbal..    (ft)      0.287
Je     Load Inertia about the Gimbal ....... (ft-lb-sec^2)   2.2 
Be     Nozzle Bearing Viscous Damping ....... (in-lb-sec)    20.0
Kg     Gimbal Bearing Spring Constant          (in-lb/rad)   0.0000    
------------------------------------------------------------------------------------------------------------------------                                                                                 
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Rocket Plane at Mach=0.85, Q=150, Aero-Elastic Model with GAFD (Batch)                                                                                                          
System                                                                                                                                                                                                                      
Vehi_Gafd_30flx                                                                                                                                                                                                                  
------------------------------------------------------------------------------------------------------------------------                                                                                                    
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Electro-Mechanical Flap Type-B Actuator  
System
flap_ema
---------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Electro-Mechanical Rudder Type-B Actuator   
System
rudder_ema
---------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Electro-Mechanical Body-Flap Type-B Actuator
System
bodyflap_ema
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Coupled axes Mixing Matrix for Rocket-Plane, K4axmix
Matrix K4axmix                                                                                                                                                                                                              
-------------------------------------------------------------------------------------------------------------------------------                                                                                    
Run the mode selection program to select 22 Pitch Axis modes from the modal data file RocketPlane.Mod 
using the the Node locations from file RocketPlane.Nod, Select 4 force excitation points at the 
center of the four control surfaces with the force directions along z. Select 2 torque excitation 
points at the two rudders and apply pitch moments, Select 2 translation sensor points at the left 
and right nav bases sensing along the z axis. Select 1 rotational sensor point at the center nav base 
sensing pitch rotations. Then using the node map menu identify the locations of the four control 
surfaces, the engine, the 3 gyros, the accelerometers, and one disturbance point in case that you 
want to apply an excitation force in the (A,B,C,D) model
--------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR THE PITCH MODES         
Rocket Plane at Mach=0.85, Q=150, Flex Model, (22 Pitch Modes)                            
! Pitch modes from the two flap Z forces to the pitch sensor                                                

MODE # 1/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    80.049       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.11504D-01  -0.90746D-02   0.29126D+00  -0.32992D-01  -0.44843D-01   0.41524D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.97675D-02   0.47826D-02   0.29436D+00   0.33689D-01  -0.44658D-01  -0.44089D-02
LEFT RUDDER HINGE LINE POINT     81441     0.17314D+00   0.11315D-01  -0.24336D+00   0.17891D-01  -0.92933D-01  -0.15111D-01
RIGHT RUDDER HINGE LINE POINT   181441     0.17467D+00  -0.11194D-01  -0.24153D+00  -0.17202D-01  -0.92692D-01   0.14310D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.49436D-01  -0.45508D-03  -0.33501D+00   0.24732D-03  -0.73365D-01  -0.21098D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.49436D-01  -0.45508D-03  -0.33501D+00   0.24732D-03  -0.73365D-01  -0.21098D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538     0.14718D+00   0.30794D-03  -0.26919D+00   0.17007D-03  -0.56907D-01  -0.18184D-02

MODE # 2/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    106.21       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.76552D-02  -0.92385D-01   0.13606D+01  -0.34666D+00   0.63093D-01   0.11104D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.92521D-02   0.90141D-01   0.13309D+01   0.33951D+00   0.62679D-01  -0.11157D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.22391D-01   0.86309D-02  -0.20600D-01   0.86376D-02  -0.40299D-02  -0.16314D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.20824D-01   0.16819D-02  -0.15456D-01  -0.45419D-02  -0.35437D-03   0.11148D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.47210D-03   0.23624D-02  -0.69842D-02   0.51743D-03   0.12643D-01  -0.24013D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.47210D-03   0.23624D-02  -0.69842D-02   0.51743D-03   0.12643D-01  -0.24013D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.10890D-01   0.24190D-02  -0.10459D-01   0.29842D-02  -0.13584D-03   0.25432D-02

MODE # 3/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.08       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.97636D-02   0.33171D-02  -0.32694D-01   0.11974D-01   0.77802D-02   0.15581D-03
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.87838D-02  -0.17282D-02  -0.33354D-01  -0.12079D-01   0.76386D-02   0.27519D-04
LEFT RUDDER HINGE LINE POINT     81441    -0.18589D-01   0.26137D+00  -0.12665D+00   0.31476D+00  -0.41941D+00  -0.51425D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.19071D-01  -0.25614D+00  -0.12360D+00  -0.30882D+00  -0.41088D+00   0.50430D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.97709D-02   0.13981D-03   0.79409D-01  -0.88189D-04   0.24807D-01   0.27542D-04

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.97709D-02   0.13981D-03   0.79409D-01  -0.88189D-04   0.24807D-01   0.27542D-04

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.13888D-01  -0.18176D-01   0.89578D-01   0.31518D-01  -0.82099D-04  -0.35170D-02

MODE # 4/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    139.89       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.17941D+00   0.72041D-01   0.33542D+00  -0.78973D-01   0.31461D-01   0.34968D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.16966D+00   0.76975D-01  -0.23760D+00  -0.56332D-01  -0.26670D-01   0.31703D-01
LEFT RUDDER HINGE LINE POINT     81441     0.18338D+00  -0.35546D-01  -0.10370D+00   0.15024D+00  -0.26848D+00  -0.17864D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.17382D+00  -0.30012D-01   0.96662D-01   0.15712D+00   0.27341D+00  -0.19498D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.96048D-03  -0.21118D+00  -0.74715D-02   0.91171D-03  -0.34525D-02   0.30360D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.96048D-03  -0.21118D+00  -0.74715D-02   0.91171D-03  -0.34525D-02   0.30360D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.61213D-01  -0.16998D+00  -0.12219D-01  -0.95908D-02   0.44280D-02   0.34914D-01

MODE # 5/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    152.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.62364D-01   0.30843D-01  -0.57249D+00   0.11734D+00  -0.31447D-01  -0.24464D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.90041D-01  -0.18808D-01  -0.62485D+00  -0.13148D+00  -0.36842D-01   0.29835D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.26735D-01   0.40879D-02   0.21715D-01   0.14748D-01   0.42806D-02  -0.36604D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.67547D-01  -0.17020D-01   0.37646D-01  -0.99377D-02   0.20595D-01   0.53115D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.22799D-01  -0.18308D-01   0.58843D-01   0.23209D-02   0.35487D-01   0.27840D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.22799D-01  -0.18308D-01   0.58843D-01   0.23209D-02   0.35487D-01   0.27840D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00   0.16418D-02   0.80898D-01   0.29896D-02
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00   0.16418D-02   0.80898D-01   0.29896D-02
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00   0.16418D-02   0.80898D-01   0.29896D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00
CENTER NAVIGATION BASE           22426    -0.94221D-01   0.11407D-01   0.19618D+00

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.14719D-01  -0.12009D-01   0.48469D-01   0.76648D-02   0.98291D-02   0.74454D-02

MODE # 6/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    174.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.11413D-01  -0.17332D-01   0.28337D-01  -0.10856D-01  -0.13600D-01   0.33386D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.77301D-02  -0.42626D-02   0.86712D-01   0.29734D-01  -0.90546D-02  -0.10725D-02
LEFT RUDDER HINGE LINE POINT     81441    -0.50040D+00  -0.14653D-01   0.13047D+00   0.25444D-01   0.26962D+00  -0.33121D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.56425D+00  -0.41249D-01   0.12007D+00  -0.80971D-02   0.34310D+00   0.32645D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.25698D-01  -0.23582D-01   0.21006D+00  -0.42739D-02   0.25229D+00   0.17062D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.25698D-01  -0.23582D-01   0.21006D+00  -0.42739D-02   0.25229D+00   0.17062D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01   0.38503D-03  -0.66226D-02   0.30360D-02
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01   0.38503D-03  -0.66226D-02   0.30360D-02
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01   0.38503D-03  -0.66226D-02   0.30360D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01
CENTER NAVIGATION BASE           22426    -0.12110D-01   0.68195D-02   0.54767D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.55027D-01  -0.58177D-01   0.14789D+00   0.29490D-01   0.40124D-01   0.31730D-01

MODE # 7/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    187.74       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.56989D-01  -0.30457D-01  -0.15421D+00   0.66675D-01   0.17176D-02  -0.60231D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.39516D-01  -0.48706D-01  -0.46445D-01  -0.24517D-01   0.12739D-02   0.14743D-02
LEFT RUDDER HINGE LINE POINT     81441     0.51235D+00  -0.10033D+00   0.37524D-01   0.68871D-03  -0.41041D+00   0.22164D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.98215D-01  -0.48668D-01  -0.17903D-01   0.28621D-01   0.10793D+00   0.48358D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.37672D-01  -0.11493D-01  -0.33126D-01  -0.11908D-01  -0.10259D+00  -0.20928D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.37672D-01  -0.11493D-01  -0.33126D-01  -0.11908D-01  -0.10259D+00  -0.20928D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00   0.88085D-02   0.15483D-01   0.46816D-02
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00   0.88085D-02   0.15483D-01   0.46816D-02
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00   0.88085D-02   0.15483D-01   0.46816D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00
CENTER NAVIGATION BASE           22426    -0.94369D-01  -0.10100D-01  -0.12517D+00

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538     0.38351D-01  -0.85368D-01  -0.41343D-01  -0.15485D-01   0.34578D-03   0.13860D-01

MODE # 8/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    191.66       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.10524D-01   0.16953D-01  -0.80601D-01   0.37195D-01  -0.67365D-02   0.64142D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.10202D+00  -0.53278D-03  -0.11634D+00  -0.56932D-01   0.29217D-02   0.12856D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.25575D+00  -0.13894D-01  -0.11109D-01  -0.14241D-01   0.20337D+00  -0.17917D+00
RIGHT RUDDER HINGE LINE POINT   181441     0.48296D+00   0.40397D-01   0.46021D-01   0.17247D-01  -0.37775D+00  -0.23326D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.34377D-01  -0.71635D-01  -0.21858D-01   0.58121D-02  -0.77920D-01   0.92247D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.34377D-01  -0.71635D-01  -0.21858D-01   0.58121D-02  -0.77920D-01   0.92247D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00  -0.73553D-02   0.15726D-01   0.14277D-01
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00  -0.73553D-02   0.15726D-01   0.14277D-01
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00  -0.73553D-02   0.15726D-01   0.14277D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00
CENTER NAVIGATION BASE           22426    -0.98444D-01   0.32020D-01  -0.13636D+00

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538     0.41471D-01   0.16469D-01   0.15344D-01   0.24891D-03  -0.29466D-01  -0.14717D-02

MODE # 9/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    197.96       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.40493D-01   0.20132D-01  -0.96192D-01   0.64493D-01  -0.37609D-02   0.29217D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.65020D-01   0.64252D-02  -0.10131D+00  -0.64878D-01  -0.61826D-02  -0.70801D-02
LEFT RUDDER HINGE LINE POINT     81441    -0.35918D-01   0.28944D-01   0.53188D-01   0.14604D-01   0.45952D-01  -0.11836D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.10800D+00  -0.60591D-02   0.39619D-01  -0.20045D-01   0.99203D-01   0.57194D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.18941D-01   0.23957D-01   0.56693D-01  -0.95477D-03   0.19370D+00  -0.15168D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.18941D-01   0.23957D-01   0.56693D-01  -0.95477D-03   0.19370D+00  -0.15168D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00   0.39075D-02  -0.76919D-02  -0.78351D-02
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00   0.39075D-02  -0.76919D-02  -0.78351D-02
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00   0.39075D-02  -0.76919D-02  -0.78351D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00
CENTER NAVIGATION BASE           22426     0.64846D-01  -0.12836D-01  -0.20440D+00

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538     0.14083D-01   0.74298D-02   0.56530D-01   0.33000D-02  -0.11015D-01  -0.42803D-02

MODE #10/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    212.28       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.83480D-01   0.81759D-01  -0.15687D+00   0.54831D-01   0.95507D-02   0.56544D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.89734D-01   0.83681D-01   0.55333D-01   0.28769D-01   0.96045D-02   0.15385D-01
LEFT RUDDER HINGE LINE POINT     81441     0.10642D+00  -0.12391D+00   0.27646D+00   0.54135D-01  -0.18107D+00  -0.79518D-01
RIGHT RUDDER HINGE LINE POINT   181441     0.25123D+00  -0.16154D+00   0.16471D-02  -0.11191D-01  -0.14295D+00  -0.30636D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37463D-01  -0.72375D-01   0.22229D+00  -0.58679D-01   0.37922D+00   0.21313D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37463D-01  -0.72375D-01   0.22229D+00  -0.58679D-01   0.37922D+00   0.21313D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01   0.84312D-01   0.14697D-01  -0.29894D-01
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01   0.84312D-01   0.14697D-01  -0.29894D-01
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01   0.84312D-01   0.14697D-01  -0.29894D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01
CENTER NAVIGATION BASE           22426     0.51651D-02  -0.88335D-01   0.75592D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.73854D-01  -0.20060D+00   0.65565D-01  -0.66043D-01   0.11262D-01   0.10880D-01

MODE #11/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    213.34       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.82634D-01  -0.14071D-01  -0.15927D-01   0.12720D-02   0.32561D-01  -0.15804D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.29162D-01  -0.15080D-01  -0.20252D+00  -0.70445D-01   0.14175D-01   0.35392D-02
LEFT RUDDER HINGE LINE POINT     81441     0.22007D+00   0.11137D+00   0.55177D-01   0.71670D-02  -0.13803D+00   0.20623D+00
RIGHT RUDDER HINGE LINE POINT   181441     0.10907D+00   0.94893D-01   0.20621D+00  -0.39364D-01  -0.14707D+00   0.37735D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37273D-01   0.66994D-01   0.19565D+00   0.33901D-01   0.33495D+00  -0.12356D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.37273D-01   0.66994D-01   0.19565D+00   0.33901D-01   0.33495D+00  -0.12356D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01  -0.49634D-01   0.36590D-01  -0.50653D-02
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01  -0.49634D-01   0.36590D-01  -0.50653D-02
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01  -0.49634D-01   0.36590D-01  -0.50653D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01
CENTER NAVIGATION BASE           22426    -0.25886D-01   0.43876D-01   0.88321D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538     0.48520D-02   0.13745D+00   0.22952D+00   0.31261D-01   0.25466D-02  -0.13927D-01

MODE #12/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    217.34       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.40299D-02   0.19201D-02   0.53943D-01  -0.19972D-01  -0.31820D-01  -0.15372D-03
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.45169D-01  -0.89966D-03  -0.33944D-01  -0.12068D-01  -0.41449D-01  -0.50529D-02
LEFT RUDDER HINGE LINE POINT     81441     0.24933D+00   0.64744D-01   0.17729D+00   0.34012D-01  -0.22368D+00   0.19362D+00
RIGHT RUDDER HINGE LINE POINT   181441     0.20682D+00   0.27358D-01   0.23834D+00  -0.47408D-01  -0.22941D+00  -0.95107D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.31758D-01   0.31171D-01   0.32350D+00   0.13782D-01   0.57805D+00  -0.50773D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.31758D-01   0.31171D-01   0.32350D+00   0.13782D-01   0.57805D+00  -0.50773D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01  -0.21513D-01  -0.19543D-01  -0.97179D-02
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01  -0.21513D-01  -0.19543D-01  -0.97179D-02
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01  -0.21513D-01  -0.19543D-01  -0.97179D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01
CENTER NAVIGATION BASE           22426    -0.30844D-02   0.15515D-01  -0.36464D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.56718D-01   0.59443D-01   0.28981D+00   0.86756D-02   0.92774D-02  -0.99327D-02

MODE #13/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    231.42       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.25081D+00  -0.36049D-01  -0.18362D+00   0.57122D-01  -0.73392D-01  -0.51381D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.23370D+00  -0.38874D-01   0.10456D+00   0.33550D-01   0.50047D-01  -0.45578D-01
LEFT RUDDER HINGE LINE POINT     81441     0.10092D+00   0.18066D+00   0.38837D-01  -0.31389D-01  -0.76546D-01   0.13518D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.79330D-01   0.18455D+00  -0.11537D-01  -0.31885D-01   0.59092D-01   0.13303D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.14532D-02   0.27341D+00   0.15647D-01   0.10699D-01   0.43523D-01  -0.34131D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.14532D-02   0.27341D+00   0.15647D-01   0.10699D-01   0.43523D-01  -0.34131D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01   0.41521D-01   0.47452D-02   0.13802D+00
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01   0.41521D-01   0.47452D-02   0.13802D+00
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01   0.41521D-01   0.47452D-02   0.13802D+00

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01
CENTER NAVIGATION BASE           22426    -0.68409D-02  -0.10101D+00  -0.15168D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538     0.44622D-01   0.20998D+00   0.25057D-01   0.22916D-02  -0.36726D-03  -0.20004D-01

MODE #14/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    240.46       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.30858D-01  -0.30933D-01   0.41221D+00  -0.14163D+00   0.14705D+00   0.23637D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.74871D-01   0.21121D-01   0.38835D+00   0.13520D+00   0.13456D+00  -0.30014D-01
LEFT RUDDER HINGE LINE POINT     81441     0.79444D-01   0.24622D-01   0.65734D-01   0.64805D-02  -0.12575D+00   0.83713D-01
RIGHT RUDDER HINGE LINE POINT   181441     0.59273D-01   0.19656D-01   0.54761D-01  -0.15535D-01  -0.10329D+00  -0.52758D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34466D-01   0.36712D-01   0.17774D+00   0.43965D-03   0.38563D+00  -0.48072D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34466D-01   0.36712D-01   0.17774D+00   0.43965D-03   0.38563D+00  -0.48072D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00   0.62979D-03  -0.74072D-01   0.12410D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00
CENTER NAVIGATION BASE           22426    -0.12455D+00  -0.14554D-01   0.18490D+00

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.91984D-01   0.28090D-01   0.10084D+00  -0.50378D-02   0.46074D-01  -0.19893D-02

MODE #15/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    259.96       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.62091D-01  -0.10672D-01   0.11528D+00  -0.43441D-01   0.39589D-01   0.88119D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.66919D-01   0.56771D-02   0.12306D+00   0.45957D-01   0.44139D-01  -0.10118D-01
LEFT RUDDER HINGE LINE POINT     81441     0.18557D-01   0.35438D-02   0.67299D-03   0.53341D-02   0.24303D-02   0.39901D-02
RIGHT RUDDER HINGE LINE POINT   181441     0.19884D-01  -0.10527D-01  -0.15258D-02  -0.48580D-02   0.41044D-02  -0.73538D-02
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.61458D-01  -0.22465D-02   0.47243D-01  -0.59987D-03   0.30357D+00   0.39131D-04

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.61458D-01  -0.22465D-02   0.47243D-01  -0.59987D-03   0.30357D+00   0.39131D-04

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01  -0.94776D-03   0.35347D-01  -0.29673D-02
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01  -0.94776D-03   0.35347D-01  -0.29673D-02
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01  -0.94776D-03   0.35347D-01  -0.29673D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01
CENTER NAVIGATION BASE           22426     0.28027D+00   0.31506D-03   0.29426D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538     0.64209D-02  -0.40493D-02   0.11756D-01   0.24009D-03   0.15884D-01   0.18011D-03

MODE #16/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    297.11       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.33864D-01   0.37649D-01   0.23169D+00  -0.48109D-01   0.14690D+00   0.60390D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.26887D-01   0.57285D-02   0.25111D+00   0.44758D-01   0.13808D+00  -0.87309D-02
LEFT RUDDER HINGE LINE POINT     81441     0.55412D-02   0.44960D-02   0.38181D-01  -0.36252D-02  -0.22969D-01  -0.48880D-02
RIGHT RUDDER HINGE LINE POINT   181441    -0.84483D-02  -0.29883D-02  -0.23369D-01  -0.45596D-02   0.48563D-02  -0.12498D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34332D-04   0.20635D-01   0.20688D-01  -0.98870D-02  -0.10540D+00   0.11896D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.34332D-04   0.20635D-01   0.20688D-01  -0.98870D-02  -0.10540D+00   0.11896D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01   0.86668D-02  -0.11380D+00  -0.11858D-01
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01   0.86668D-02  -0.11380D+00  -0.11858D-01
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01   0.86668D-02  -0.11380D+00  -0.11858D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01
CENTER NAVIGATION BASE           22426     0.16750D+01  -0.86318D-04   0.37737D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.27217D-01  -0.20243D-02  -0.49614D-02  -0.13521D-01   0.16371D-01  -0.31889D-02

MODE #17/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    317.06       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.11683D+00   0.51829D-01  -0.23021D+00   0.75142D-01  -0.12533D+00   0.69237D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.11013D+00   0.43326D-01   0.34229D+00   0.86069D-01   0.23874D+00   0.68409D-03
LEFT RUDDER HINGE LINE POINT     81441     0.23572D-01   0.43963D-01  -0.69840D-01   0.15941D-01   0.69693D-01   0.16250D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.98144D-02   0.37857D-01   0.67110D-01   0.16847D-01  -0.57592D-01   0.24501D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10415D-01  -0.59507D-01  -0.38869D-02   0.25894D-01   0.16844D-01   0.12758D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10415D-01  -0.59507D-01  -0.38869D-02   0.25894D-01   0.16844D-01   0.12758D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02   0.49641D-01   0.67975D-01   0.16358D+00
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02   0.49641D-01   0.67975D-01   0.16358D+00
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02   0.49641D-01   0.67975D-01   0.16358D+00

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02
CENTER NAVIGATION BASE           22426    -0.29484D+00   0.11374D+00   0.79587D-02

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.30818D-01   0.25622D-01   0.41221D-01   0.17267D-01   0.29466D-02   0.16911D-01

MODE #18/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    319.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.50196D-01  -0.40789D-01  -0.38652D+00   0.12459D-01  -0.44580D+00  -0.87010D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.38709D-01   0.40601D-01  -0.28800D+00   0.10989D-01  -0.37014D+00   0.19376D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.48973D-01   0.31855D-02   0.49316D-01   0.12474D-01  -0.63510D-01   0.55286D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.53112D-01   0.40017D-01   0.70281D-01  -0.66606D-02  -0.82421D-01  -0.31104D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.71547D-01   0.54607D-02   0.10848D+00   0.44828D-02  -0.43449D+00  -0.18257D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.71547D-01   0.54607D-02   0.10848D+00   0.44828D-02  -0.43449D+00  -0.18257D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01   0.87047D-02  -0.47418D+00   0.14554D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01
CENTER NAVIGATION BASE           22426     0.19399D+01   0.23460D-01  -0.31904D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.12443D+00   0.12328D-01   0.10169D+00   0.53511D-02   0.74090D-02   0.21169D-01

MODE #19/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    331.28       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.87552D-01  -0.26330D-01   0.59045D-02  -0.39502D-01  -0.93514D-01   0.80926D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.87060D-01   0.12492D-01  -0.40659D-01   0.24659D-01  -0.12282D+00  -0.50523D-02
LEFT RUDDER HINGE LINE POINT     81441     0.11650D-01   0.10751D-01   0.66156D-01   0.10817D-01  -0.27441D-01   0.16791D-01
RIGHT RUDDER HINGE LINE POINT   181441     0.14078D-01  -0.51422D-02   0.44575D-01  -0.14211D-01  -0.13102D-01  -0.15636D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.40971D-01   0.13070D-01   0.91515D-01  -0.35541D-02  -0.35166D+00  -0.19143D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.40971D-01   0.13070D-01   0.91515D-01  -0.35541D-02  -0.35166D+00  -0.19143D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01  -0.62554D-02   0.61179D+00  -0.87561D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01
CENTER NAVIGATION BASE           22426    -0.22901D+01  -0.48717D-03  -0.43560D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.13403D-01   0.37829D-03   0.69875D-01   0.19023D-02   0.12148D-01   0.42055D-03

MODE #20/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    338.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.16520D+00   0.38899D-01   0.89818D-01  -0.13882D-01   0.10877D+00  -0.19167D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.58278D-01  -0.16687D-02   0.28248D-01  -0.85748D-03   0.46491D-01   0.29172D-02
LEFT RUDDER HINGE LINE POINT     81441    -0.31651D-01  -0.29139D-01  -0.26383D-01   0.27623D-02  -0.26053D-02   0.13570D-02
RIGHT RUDDER HINGE LINE POINT   181441    -0.34605D-01  -0.22298D-01  -0.30291D-01  -0.67459D-02   0.21949D-02  -0.30795D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.48754D-01  -0.21776D-01  -0.15673D-01  -0.20327D-02   0.33889D-01   0.38638D-02

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.48754D-01  -0.21776D-01  -0.15673D-01  -0.20327D-02   0.33889D-01   0.38638D-02

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02  -0.61511D-02   0.14494D+00   0.67076D-02
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02  -0.61511D-02   0.14494D+00   0.67076D-02
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02  -0.61511D-02   0.14494D+00   0.67076D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02
CENTER NAVIGATION BASE           22426    -0.57495D+00  -0.69441D-02  -0.89847D-02

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.63408D-01  -0.30692D-01  -0.28472D-02  -0.29323D-01   0.33512D-01   0.28261D-01

MODE #21/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    359.54       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.41184D+00   0.54617D-01  -0.45819D-01  -0.21406D-01  -0.14563D+00  -0.66295D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.40355D+00  -0.43448D-01   0.61745D-02   0.30384D-01  -0.85559D-01   0.60470D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.92831D-01  -0.27625D-01  -0.19442D-02  -0.13571D-01  -0.66657D-01   0.22992D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.91628D-01   0.23680D-01   0.16386D-01   0.14687D-01  -0.73300D-01  -0.21622D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11383D+00  -0.58277D-02   0.90839D-01   0.25959D-02  -0.47449D-01   0.71110D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11383D+00  -0.58277D-02   0.90839D-01   0.25959D-02  -0.47449D-01   0.71110D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01   0.95477D-02   0.19424D+01   0.60023D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01
CENTER NAVIGATION BASE           22426    -0.55959D+01  -0.65118D-03  -0.10441D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.18130D+00   0.40456D-02   0.32554D-01   0.41406D-02   0.33371D-01  -0.47347D-04

MODE #22/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    359.89       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.13928D+00   0.17836D-01  -0.95513D-01   0.93761D-02  -0.78782D-01  -0.26915D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.15501D+00  -0.19435D-01  -0.69515D-01  -0.47754D-02  -0.50925D-01   0.27986D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.26797D-01  -0.38884D-02  -0.13625D-01  -0.78677D-02  -0.13237D-01   0.27622D-02
RIGHT RUDDER HINGE LINE POINT   181441    -0.25528D-01   0.85973D-02  -0.76898D-02   0.85163D-02  -0.15341D-01   0.99894D-03
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.40331D-01   0.13277D-02   0.18228D-02   0.10260D-02   0.59038D-01  -0.37225D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.40331D-01   0.13277D-02   0.18228D-02   0.10260D-02   0.59038D-01  -0.37225D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02   0.16493D-03  -0.45729D+01  -0.25288D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02
CENTER NAVIGATION BASE           22426     0.12839D+02  -0.14553D-02  -0.11929D-02

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.43469D-01   0.56260D-02  -0.12023D-01   0.24928D-03   0.78490D-02  -0.21047D-02
--------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR MIXED AXES MODES          
Rocket Plane at Mach=0.85, Q=150, Flex Model, (30 Mixed Modes)                                             
! Select 30 flex modes from all three, roll, pitch, and yaw axes

MODE # 1/  1, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.168       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.88837D-01   0.80693D-01  -0.31931D+00   0.55369D-01  -0.15543D-01   0.10639D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.90890D-01   0.80487D-01   0.32028D+00   0.54879D-01   0.15552D-01   0.10600D-01
LEFT RUDDER HINGE LINE POINT     81441     0.11619D+00   0.11498D+00  -0.20924D+00   0.70946D-01  -0.21047D-01   0.19172D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.11864D+00   0.11503D+00   0.21196D+00   0.71042D-01   0.21263D-01   0.19094D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11188D-02  -0.16957D+00   0.13759D-02   0.61874D-01   0.41981D-04   0.28465D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.11188D-02  -0.16957D+00   0.13759D-02   0.61874D-01   0.41981D-04   0.28465D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02  -0.12250D+00   0.42723D-03   0.65102D-01
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02  -0.12250D+00   0.42723D-03   0.65102D-01
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02  -0.12250D+00   0.42723D-03   0.65102D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02
CENTER NAVIGATION BASE           22426    -0.18752D-02  -0.18791D+00  -0.11932D-02

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.65461D-01   0.75161D-01   0.12025D+00   0.57916D-01   0.14990D-02   0.32534D-01

MODE # 2/  2, Frequency (rad/sec), Damping (zeta), Generalized Mass=    80.049       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.11504D-01  -0.90746D-02   0.29126D+00  -0.32992D-01  -0.44843D-01   0.41524D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.97675D-02   0.47826D-02   0.29436D+00   0.33689D-01  -0.44658D-01  -0.44089D-02
LEFT RUDDER HINGE LINE POINT     81441     0.17314D+00   0.11315D-01  -0.24336D+00   0.17891D-01  -0.92933D-01  -0.15111D-01
RIGHT RUDDER HINGE LINE POINT   181441     0.17467D+00  -0.11194D-01  -0.24153D+00  -0.17202D-01  -0.92692D-01   0.14310D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.49436D-01  -0.45508D-03  -0.33501D+00   0.24732D-03  -0.73365D-01  -0.21098D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.49436D-01  -0.45508D-03  -0.33501D+00   0.24732D-03  -0.73365D-01  -0.21098D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01   0.15825D-02   0.44080D-01  -0.58234D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01
CENTER NAVIGATION BASE           22426    -0.78988D-01   0.18369D-02   0.58043D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538     0.14718D+00   0.30794D-03  -0.26919D+00   0.17007D-03  -0.56907D-01  -0.18184D-02

MODE # 3/  3, Frequency (rad/sec), Damping (zeta), Generalized Mass=    106.21       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.76552D-02  -0.92385D-01   0.13606D+01  -0.34666D+00   0.63093D-01   0.11104D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.92521D-02   0.90141D-01   0.13309D+01   0.33951D+00   0.62679D-01  -0.11157D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.22391D-01   0.86309D-02  -0.20600D-01   0.86376D-02  -0.40299D-02  -0.16314D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.20824D-01   0.16819D-02  -0.15456D-01  -0.45419D-02  -0.35437D-03   0.11148D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.47210D-03   0.23624D-02  -0.69842D-02   0.51743D-03   0.12643D-01  -0.24013D-03

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.47210D-03   0.23624D-02  -0.69842D-02   0.51743D-03   0.12643D-01  -0.24013D-03

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01  -0.12972D-02   0.16810D-01  -0.73516D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01
CENTER NAVIGATION BASE           22426    -0.20200D-01  -0.54783D-03  -0.32077D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.10890D-01   0.24190D-02  -0.10459D-01   0.29842D-02  -0.13584D-03   0.25432D-02

MODE # 4/  4, Frequency (rad/sec), Damping (zeta), Generalized Mass=    117.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.15061D-01   0.16560D+00  -0.95724D+00   0.23160D+00  -0.26275D-01  -0.66365D-02
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.12838D-01   0.16971D+00   0.10226D+01   0.24805D+00   0.29250D-01  -0.76581D-02
LEFT RUDDER HINGE LINE POINT     81441     0.26032D-01  -0.24549D+00   0.21762D+00  -0.19380D+00   0.20743D+00   0.25555D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.24370D-01  -0.24715D+00  -0.22345D+00  -0.19597D+00  -0.21114D+00   0.25847D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.16584D-03   0.79641D-02  -0.26760D-02  -0.38358D-01  -0.54629D-03   0.10822D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.16584D-03   0.79641D-02  -0.26760D-02  -0.38358D-01  -0.54629D-03   0.10822D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02   0.21564D-02  -0.37031D-03   0.10835D-01
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02   0.21564D-02  -0.37031D-03   0.10835D-01
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02   0.21564D-02  -0.37031D-03   0.10835D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02
CENTER NAVIGATION BASE           22426     0.53956D-03   0.24379D-01  -0.16717D-02

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.12094D-01  -0.12761D+00  -0.63818D-01  -0.22036D-01  -0.66178D-02   0.39445D-02

MODE # 5/  5, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.08       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.97636D-02   0.33171D-02  -0.32694D-01   0.11974D-01   0.77802D-02   0.15581D-03
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.87838D-02  -0.17282D-02  -0.33354D-01  -0.12079D-01   0.76386D-02   0.27519D-04
LEFT RUDDER HINGE LINE POINT     81441    -0.18589D-01   0.26137D+00  -0.12665D+00   0.31476D+00  -0.41941D+00  -0.51425D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.19071D-01  -0.25614D+00  -0.12360D+00  -0.30882D+00  -0.41088D+00   0.50430D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.97709D-02   0.13981D-03   0.79409D-01  -0.88189D-04   0.24807D-01   0.27542D-04

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.97709D-02   0.13981D-03   0.79409D-01  -0.88189D-04   0.24807D-01   0.27542D-04

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01  -0.12776D-03  -0.52485D-02   0.18821D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01
CENTER NAVIGATION BASE           22426     0.13991D-01   0.52761D-04  -0.29980D-01

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.13888D-01  -0.18176D-01   0.89578D-01   0.31518D-01  -0.82099D-04  -0.35170D-02

MODE # 6/  6, Frequency (rad/sec), Damping (zeta), Generalized Mass=    139.89       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008     0.17941D+00   0.72041D-01   0.33542D+00  -0.78973D-01   0.31461D-01   0.34968D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.16966D+00   0.76975D-01  -0.23760D+00  -0.56332D-01  -0.26670D-01   0.31703D-01
LEFT RUDDER HINGE LINE POINT     81441     0.18338D+00  -0.35546D-01  -0.10370D+00   0.15024D+00  -0.26848D+00  -0.17864D+00
RIGHT RUDDER HINGE LINE POINT   181441    -0.17382D+00  -0.30012D-01   0.96662D-01   0.15712D+00   0.27341D+00  -0.19498D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.96048D-03  -0.21118D+00  -0.74715D-02   0.91171D-03  -0.34525D-02   0.30360D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270    -0.96048D-03  -0.21118D+00  -0.74715D-02   0.91171D-03  -0.34525D-02   0.30360D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02   0.26012D-01  -0.40135D-02   0.39095D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02
CENTER NAVIGATION BASE           22426     0.52853D-02   0.11072D+00  -0.82928D-02

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538    -0.61213D-01  -0.16998D+00  -0.12219D-01  -0.95908D-02   0.44280D-02   0.34914D-01

MODE # 7/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    144.36       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.10313D+00   0.59976D-01  -0.92321D+00   0.24665D+00  -0.58141D-01  -0.28657D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008     0.10084D+00   0.58624D-01   0.88260D+00   0.23939D+00   0.55242D-01  -0.27078D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.14699D+00   0.69855D-01   0.10645D+00   0.14526D+00  -0.25342D+00  -0.42415D+00
RIGHT RUDDER HINGE LINE POINT   181441     0.15481D+00   0.73395D-01  -0.11367D+00   0.14950D+00   0.25655D+00  -0.43475D+00
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10862D-02   0.17274D+00  -0.56238D-02  -0.73630D-01  -0.18669D-02  -0.20976D-01

                              Node ID#     Modal Data at the  1 Engines, (x,y,z)...
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.10862D-02   0.17274D+00  -0.56238D-02  -0.73630D-01  -0.18669D-02  -0.20976D-01

                              Node ID#     Modal Data at the  3 Gyros ...
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02  -0.48928D-01   0.20260D-02  -0.20227D-01
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02  -0.48928D-01   0.20260D-02  -0.20227D-01
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02  -0.48928D-01   0.20260D-02  -0.20227D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02
CENTER NAVIGATION BASE           22426    -0.42642D-03  -0.38130D-02   0.35532D-02

                              Node ID#     Modal Data at the Disturbance Point 
Thruster RUa, +Z                113538     0.49417D-01  -0.68279D-01  -0.16146D+00  -0.90131D-01   0.14827D-02  -0.22316D-01

MODE # 8/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    152.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Control Surfaces (Hinges) 
LEFT OUTBOARD FLAP HINGE LINE    60008    -0.62364D-01   0.30843D-01  -0.57249D+00   0.11734D+00  -0.31447D-01  -0.24464D-01
RIGHT OUTBOARD FLAP HINGE LINE  160008    -0.90041D-01  -0.18808D-01  -0.62485D+00  -0.13148D+00  -0.36842D-01   0.29835D-01
LEFT RUDDER HINGE LINE POINT     81441    -0.26735D-01   0.40879D-02   0.21715D-01   0.14748D-01   0.42806D-02  -0.36604D-01
RIGHT RUDDER HINGE LINE POINT   181441    -0.67547D-01  -0.17020D-01   0.37646D-01  -0.99377D-02   0.20595D-01   0.53115D-01
BODY FLAP HINGE (ENGINE GIMBAL   70270     0.22799D-01  -0.18308D-01   0.58843D-01   0.23209D-02   0.35487D-01   0.27840D-02

