BATCH MODE INSTRUCTIONS ...............                                                             
Batch set for creating a Flap actuator model
! This Batch generates an actuator model. 
! It also saves it as Matlab function for further analysis
!
Actuator Model   : Electro-Mechanical Flap Actuator        
To Matlab Format : Electro-Mechanical Flap Actuator         
--------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ ELECTROMECHANICAL TYPE B 
Electro-Mechanical Flap Actuator
! This EMA system has a full PID controller with a second order compensator
!
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      2, 1.2,2000.0, 0.6,250.0
Kpl    Position Error Loop Gain                 (Volt/ft)    60.0
Krf    Rate Feedback Gain                   (Volt/ft/sec)    0.00045
Ki     Position Error Integral Gain         (Volt/ft-sec)    10.0
Wm     Servo Motor Bandwidth,                 (rad/sec)      1200.0
Kv     Servo Motor Torque Gain               (ft-lb/volt)    100.0
Jm     Motor Rotor Moment of Inertia         (ft-lb-sec^2)   2.0e-5
Ngr    Gear Ratio (Motor Turns/ Screw Turns)        ( - )    10.25
Nscr   Screw Ratio (Piston Extension/Screw Turns) (ft/rad)   0.0026
Kgs    Motor Gear Stiffness                    (ft-lb/rad)   350.0
Kmfr   Motor/ Gear Friction                (ft-lb/rad/sec)   0.03
Kdmp   Shaft Damping Friction              (ft-lb/rad/sec)   0.004
Keff   Gear Effectiveness Coefficient               ( - )    0.8
Ja     Gear plus Screw Inertia               (ft-lb-sec^2)   4.6e-4
Kact   Actuator Stiffness (Piston+Electric).... (lb/ft)      2.0e+6
Klod   Load Stiffness,(Con. Surface or Nozzle)  (lb/ft)      0.5e+6
Kbck   Vehicle Backup Structure Stiffness ..... (lb/ft)      0.5e+6
R      Moment Arm of Actuator Shaft from Gimbal..  (feet)    0.4
Je     Load Inertia about the Gimbal ....... (ft-lb-sec^2)   0.4 
Be     Aero-Surface Bearing Viscous Damping   (ft-lb-sec)    30.0
Kg     Aero-Surface Bearing Spring Constant   (ft-lb/rad)    0.0    
------------------------------------------------------------------------------------------------------------------------
       MATLAB CONVERSIONS
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Electro-Mechanical Flap Actuator  
System
Flap_ema_b
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-