BATCH MODE INSTRUCTIONS ...............                                                             
Batch set for creating a Rudder actuator models
! This Batch generates the Rudder Actuator model and saves it in Matlab
!
Actuator Model   : Electro-Mechanical Rudder Actuator, Type-B (feet)         
To Matlab Format : Electro-Mechanical Rudder Actuator, Type-B (feet)
--------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ ELECTROMECHANICAL TYPE B 
Electro-Mechanical Rudder Actuator, Type-B (feet)
! This EMA actuator Uses an Extendable Shaft to Drive a Load.
! The end of the rod is attached to a lever arm that rotates the Aero-Surface.
! Input-1 is the Deflection command in (rad)
! Input-2 is the Load-Torque in (foot pounds)
! The Outputs are all in radians
!
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      1, 0.0, 0.01
Kpl    Position Error Loop Gain                 (Volt/ft)    480.0
Krf    Rate Feedback Gain                   (Volt/in/sec)    0.004
Ki     Position Error Integral Gain         (Volt/ft-sec)    1.2
Wm     Servo Motor Bandwidth,                 (rad/sec)      2000.0
Kv     Servo Motor Torque Gain               (ft-lb/volt)    300.0
Jm     Motor Rotor Moment of Inertia         (ft-lb-sec^2)   0.8e-4
Ngr    Gear Ratio (Motor Turns/ Screw Turns)        ( - )    17.0
Nscr   Screw Ratio (Piston Extension/Screw Turns) (ft/rad)   0.0027
Kgs    Motor Gear Stiffness                    (ft-lb/rad)   700.0
Kmfr   Motor/ Gear Friction                (ft-lb/rad/sec)   0.005
Kdmp   Shaft Damping Friction              (ft-lb/rad/sec)   0.002
Keff   Gear Effectiveness Coefficient               ( - )    0.85
Ja     Gear plus Screw Moment of Inertia ... (ft-lb-sec^2)   2.5e-4
Kact   Actuator Stiffness (Piston+Electric).... (lb/ft)      0.32e+7
Klod   Load Stiffness,(Con. Surface or Nozzle)  (lb/ft)      0.34e+7
Kbck   Vehicle Backup Structure Stiffness ..... (lb/ft)      0.42e+7
R      Moment Arm of Actuator Rod from Gimbal..    (ft)      0.3
Je     Load Inertia about the Gimbal ....... (ft-lb-sec^2)   4.0 
Be     Nozzle Bearing Viscous Damping ....... (in-lb-sec)    80.0
Kg     Gimbal Bearing Spring Constant          (in-lb/rad)   0.0000    
---------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Electro-Mechanical Rudder Actuator, Type-B (feet)     
System
rudder_ema
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-