BATCH MODE INSTRUCTIONS ...............                                                             
Batch set for creating the Body-Flap actuator model
! This Batch generates the Body-Flap Actuator model and saves it in Matlab
!
Actuator Model   : Electro-Mechanical Body-Flap Actuator, Type-B (feet)         
To Matlab Format : Electro-Mechanical Body-Flap Actuator, Type-B (feet)
--------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ ELECTROMECHANICAL TYPE B 
Electro-Mechanical Body-Flap Actuator, Type-B (feet)
! This EMA actuator Uses an Extendable Shaft to Drive a Load.
! The end of the rod is attached to a lever arm that rotates the Aero-Surface.
! Input-1 is the Deflection command in (rad)
! Input-2 is the Load-Torque in (foot pounds)
! The Outputs are in radians
!
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      1, 0.0, 0.0125
Kpl    Position Error Loop Gain                 (Volt/ft)    140.0
Krf    Rate Feedback Gain                   (Volt/in/sec)    0.0005
Ki     Position Error Integral Gain         (Volt/ft-sec)    5.0
Wm     Servo Motor Bandwidth,                 (rad/sec)      1500.0
Kv     Servo Motor Torque Gain               (ft-lb/volt)    260.0
Jm     Motor Rotor Moment of Inertia         (ft-lb-sec^2)   5.0e-5
Ngr    Gear Ratio (Motor Turns/ Screw Turns)        ( - )    10.2
Nscr   Screw Ratio (Piston Extension/Screw Turns) (ft/rad)   0.0026
Kgs    Motor Gear Stiffness                    (ft-lb/rad)   400.0
Kmfr   Motor/ Gear Friction                (ft-lb/rad/sec)   0.03
Kdmp   Shaft Damping Friction              (ft-lb/rad/sec)   0.001
Keff   Gear Effectiveness Coefficient               ( - )    0.85
Ja     Gear plus Screw Moment of Inertia ... (ft-lb-sec^2)   2.0e-4
Kact   Actuator Stiffness (Piston+Electric).... (lb/ft)      2.4e+7
Klod   Load Stiffness,(Con. Surface or Nozzle)  (lb/ft)      0.36e+7
Kbck   Vehicle Backup Structure Stiffness ..... (lb/ft)      0.36e+7
R      Moment Arm of Actuator Rod from Gimbal..    (ft)      0.287
Je     Load Inertia about the Gimbal ....... (ft-lb-sec^2)   2.2 
Be     Nozzle Bearing Viscous Damping ....... (in-lb-sec)    25.0
Kg     Gimbal Bearing Spring Constant          (in-lb/rad)   0.0000    
---------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Electro-Mechanical Body-Flap Actuator, Type-B (feet)     
System
bodyflap_ema
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-